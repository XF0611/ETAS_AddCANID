; --------------------------------------------------------------------------------
; @Title: Peripheral File for Alps-CAL77S244
; @Description: V1.0
; @Author: -
; @ Copyright (c) 2020, Calterah Semiconductor, Inc.
;     All Rights Reserved
; --------------------------------------------------------------------------------

; $Id: perarcv2.per 12470 2020-10-26 17:19:46Z hlohn $
ASSERT VERSION.BUILD()>=69573. "Your require TRACE32 build 69573 or newer"

ASSERT CPUFAMILY()=="ARC" "Use this peripheral file with TRACE32 for ARC"

WAIT

ASSERT CORETYPE()>=800. "Use this peripheral for ARC-EM and ARC-HS only"

CONFIG 36.
WIDTH  18.
TREE "ETAS BIP Porting"
group aux:0x00D++0
line.long 0x00 "AUX_USER_SP,Saved User Stack Pointer"
group aux:0x0E++0
line.long 0x00 "AUX_IRQ_CTRL,Interrupt Context Saving Control Register"
bitfld.long 0x00 13. "LP      ,Indicates whether to save and restore code-density registers(EI_BASE, JLI_BASE,LDI_BASE)"
bitfld.long 0x00 11. "            U ,Indicates if user context is saved to user stack"
bitfld.long 0x00 10. "              L ,Indicates whether to save and restore loop registers(LP_COUNT, LP_START,LP_END)"
bitfld.long 0x00 9.  "            B ,Indicates whether to save and restore BLINK(ignored if NR is greater than or equal to 16.)"
bitfld.long 0x00 0--4 "           NR ,Indicates number of general-purpose register pairs saved, from 0 to 8/16 depending on RGF_NUM_REGS."
group aux:0x25++0
line.long 0x00 "INT_VECTOR_BASE,Interrupt Vector Base Register"
bitfld.long 0x00 10.--31. "INT_VECTOR_BASE      ,It contains the base address of the interrupt vectors."
group aux:0xDB++0
line.long 0x00 "SEC_BUILD,Secure Build Configuration Register"
TREE.END
TREE "Core"
group.long aux:0x02++1
line.long 0x00 "LP_START,Loop Start Address Register"
hexmask.long 0x00 1.--31. 2 "LP_START,Loop Start Address"
line.long 0x04 "LP_END,Loop End Address Register"
hexmask.long 0x04 1.--31. 2 "LP_END  ,Loop End Address"
rgroup.long aux:0x04++0
line.long 0x00 "IDENTITY,Processor Identification Register"
hexmask.long.word 0x00 16.--31. 1 "CHIPID  ,Chip Identifier Assigned"
hexmask.long.byte 0x00 08.--15. 1 "         ARCNUM  , Identity Number"
hexmask.long.byte 0x00 00.--07. 1 "       ARCVER ,Version Number"
sgroup
getx aux:0x04 %Long 0
constx 4 %byte 0
varx   4 %byte PER.B.B(4)+conv.booltoint((PER.B.L(0)&0xff)>=0x10)+conv.booltoint((PER.B.L(0)&0xff)>=0x20)
varx   4 %byte PER.B.B(4)+conv.booltoint((PER.B.L(0)&0xff)>=0x25)+conv.booltoint((PER.B.L(0)&0xff)>=0x30)
varx   4 %byte PER.B.B(4)+conv.booltoint((PER.B.L(0)&0xff)>=0x40)+conv.booltoint((PER.B.L(0)&0xff)>=0x41)
varx   4 %byte PER.B.B(4)+conv.booltoint((PER.B.L(0)&0xff)>=0x50)+conv.booltoint((PER.B.L(0)&0xff)>=0x60)
bitfld.byte 0x04 00.--04. " -> " "ARCtangent-A4,ARCtangent-A5,ARC600,ARC601,ARC700,ARC-EM 1.0,ARC-EM 1.1,ARC-HS,?..."
rgroup.long aux:0x05++0
line.long 0x00 "DEBUG,Debug Register"
bitfld.long 0x00 31. "LD      ,Load Pending Bit" "Not pending,Pending"
bitfld.long 0x00 30. "  SH ,Self Halt" "-,Self Halt"
bitfld.long 0x00 22. "     RA ,Reset applied " "-,reset"
sif (coretype()>=811.)&&(coretype()<900.)
bitfld.long 0x00 27. "       TF ,Triple Fault " "-,triple fault."
endif
newline
// Software Breakpoints:
bitfld.long 0x00 28. "UB      ,BRK behaviour in user mode" "BRK disabled,BRK enabled"
bitfld.long 0x00 29. " BH ,Breakpoint Halt" "-,BreakPt.Halt"
// Misc:
sif coretype()<900.
bitfld.long 0x00 19. "  EP ,Enable Performance counters" "off,on"
else
bitfld.long 0x00 27. "  TF ,Triple Fault " "-,triple fault."
endif
sif ((data.long(aux:0x76)&0xFF)!=0)
newline
// Actionpoints:
hexmask.long.byte 0x00 3.--10. 1 "ASR     ,Actionpoint Status Register"
bitfld.long 0x00  2. "           AH ,Actionpoint Halt" "-,ActionPt.Halt"
sif coretype()<900.
bitfld.long 0x00 20. " ED ,Enable Debug (Clock enable for Actionpoints)" "off,on"
endif
endif
newline
hexmask.long.byte 0x00 24.--26. 1 "SM      ,Sleep Mode"
bitfld.long 0x00 21. "           EH ,External Halt (e.g. ARConnect)" "-,External Halt"
bitfld.long 0x00 23. " ZZ ,Sleep State" "-,Sleeping"
group.long aux:0x0F++0
line.long 0x00 "DEBUGI,DEBUGI register for interrupts/register banks"
bitfld.long 0x00 0. "E       ,exception or interrupt vector break functionality" "Execute ISR,Break at ISR"
sif (data.long(aux:0x6E)&0x3800)!=0
decmask.long.byte 0x00 16.--18. 1 " RB  ,Register bank override"
textfld "."
bitfld.long 0x00 29. "        RBE  ,Register Bank override Enable" "off,on"
endif
sif (coretype()<900.)&&(data.long(aux:0xDB)&0xFF)!=0
newline
bitfld.long 0x00 24. "CM      ,Core Security Mode"         "non-secure,secure"
bitfld.long 0x00 25. "   DM ,Debug-port Security Mode"  "non-secure,secure"
bitfld.long 0x00 31. "    EDC ,memory accesses by the debugger are encrypted" "off,on"
endif
group.long aux:0x06++0
line.long 0x00 "PC,Program Counter: Next Instruction Address Based on the 32-Bit Program Counter"
group.long aux:0x0a++0
line.long 0x00 "STATUS32,Status Register 32-bit"
bitfld.long  0x00 11. "Z       ,Zero Flag" "Not zero,Zero"
bitfld.long  0x00 10. "     N  ,Negative Flag" "Not negative,Negative"
bitfld.long  0x00 09. "  C  ,Carry Flag" "No carry,Carry"
bitfld.long  0x00 08. "    V  ,Overflow Flag" "No overflow,Overflow"
newline
bitfld.long  0x00 31. "IE      ,Interrupt Enable" "Disabled,Enabled"
bitfld.long  0x00 1--4 "     E  ,Interrupt priority operating level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
rbitfld.long 0x00 0.  "            H  ,Halt Bit" "Running,Halted"
sif (data.long(aux:0x6E)&0x3800)!=0
bitfld.long  0x00 16.--18. "      RB ,Register Bank" "0,1,2,3,4,5,6,7"
endif
newline
bitfld.long  0x00 05. "AE      ,Exception Active" "-,Exception"
bitfld.long  0x00 13. "    DZ ,EV_DivZero exception enable" "-,enabled"
bitfld.long  0x00 07. "       U  ,User Mode" "Kernel,User"
newline
bitfld.long  0x00 12. "L       ,Zero-Overhead Loop" "-,Loop active"
sif (coretype()<900.)&&((data.long(aux:0xDB)&0xFF)!=0)&&(((data.long(aux:0xDB)>>12.)&1)==1)
bitfld.long  0x00 21. "                   S  ,Secure Mode" "Normal,Secure"
endif
newline
bitfld.long  0x00 06. "DE      ,Delayed branch is pending" "-,Delay Slot active"
bitfld.long  0x00 14. "             SC ,Enable stack checking" "-,Check Stack"
bitfld.long  0x00 19. " AD ,Disable alignment checking" "Check Alignment,-"
newline
bitfld.long  0x00 15. "ES      ,EI_S table instruction pending" "-,Table Instr. active"
bitfld.long  0x00 20. "           US ,User Sleep mode enable" "-,User Sleep enabled"
rgroup.long aux:0x412++0
line.long 0x00 "BTA,Branch Target Address Register"
hexmask.long 0x00 1.--31. 2 "ADDRESS ,Branch Target Address"
bitfld.long 0x00 0. "     T  ,Take Branch" "don't branch,take branch"
group.long aux:0x00D++0
line.long 0x00 "AUX_USER_SP,Saved User Stack Pointer"
sif ((data.long(aux:0x65)&0xFE)!=0)
rgroup.long aux:0x41++0
line.long 0x00 "AUX_MACMODE,MAC Status and Mode Register"
button "Clear Saturation" "per.s aux:0x41 %LONG 0x00000002"
eventfld.long 0x00 9. "   S1 ,Saturation Flag 1" "0,1"
eventfld.long 0x00 8. "             S2 ,Saturation Flag 2" "0,1"
endif
sif (data.long(aux:0x0c1)>>24.)==1
group.long aux:0x290++0
line.long 0x00 "JLI_BASE,Jump and Link Indexed Base Address"
endif
sif (data.long(aux:0x0c1)>>24.)>=2
group.long aux:0x290++2
line.long 0x00 "JLI_BASE,Jump and Link Indexed Base Address"
line.long 0x04 "LDI_BASE,Load Indexed Base Address"
line.long 0x08 "EI_BASE,Execute Indexed Base Address,"
endif
sif (coretype()<900.)&&(data.long(aux:0xDB)&0xFF)!=0
newline
group.long aux:0x09++0
line.long 0x00 "SEC_STAT,Secure Status Register"
bitfld.long 0x00 05. "NIC "    "0,1"
bitfld.long 0x00 04. "  SUE "  "0,1"
bitfld.long 0x00 03. "  IRM "  "0,1"
bitfld.long 0x00 02. "  NSRU " "0,1"
bitfld.long 0x00 01. "  NSRT " "0,1"
bitfld.long 0x00 00. "  SSC "  "0,1"
endif
newline
group.long aux:0x410++0
line.long 0x00 "XPU,User Mode Extension Enable Register"
bitfld.long 0x00 31.        "U31 ,User Mode 31 Enable" "Disabled,Enabled"
bitfld.long 0x00 30. "       U30 ,User Mode 30 Enable" "Disabled,Enabled"
bitfld.long 0x00 29. "       U29 ,User Mode 29 Enable" "Disabled,Enabled"
bitfld.long 0x00 28. "       U28 ,User Mode 28 Enable" "Disabled,Enabled"
newline
bitfld.long 0x00 27.        "U27 ,User Mode 27 Enable" "Disabled,Enabled"
bitfld.long 0x00 26. "       U26 ,User Mode 26 Enable" "Disabled,Enabled"
bitfld.long 0x00 25. "       U25 ,User Mode 25 Enable" "Disabled,Enabled"
bitfld.long 0x00 24. "       U24 ,User Mode 24 Enable" "Disabled,Enabled"
newline
bitfld.long 0x00 23.        "U23 ,User Mode 23 Enable" "Disabled,Enabled"
bitfld.long 0x00 22. "       U22 ,User Mode 22 Enable" "Disabled,Enabled"
bitfld.long 0x00 21. "       U21 ,User Mode 21 Enable" "Disabled,Enabled"
bitfld.long 0x00 20. "       U20 ,User Mode 20 Enable" "Disabled,Enabled"
newline
bitfld.long 0x00 19.        "U19 ,User Mode 19 Enable" "Disabled,Enabled"
bitfld.long 0x00 18. "       U18 ,User Mode 18 Enable" "Disabled,Enabled"
bitfld.long 0x00 17. "       U17 ,User Mode 17 Enable" "Disabled,Enabled"
bitfld.long 0x00 16. "       U16 ,User Mode 16 Enable" "Disabled,Enabled"
newline
bitfld.long 0x00 15.        "U15 ,User Mode 15 Enable" "Disabled,Enabled"
bitfld.long 0x00 14. "       U14 ,User Mode 14 Enable" "Disabled,Enabled"
bitfld.long 0x00 13. "       U13 ,User Mode 13 Enable" "Disabled,Enabled"
bitfld.long 0x00 12. "       U12 ,User Mode 12 Enable" "Disabled,Enabled"
newline
bitfld.long 0x00 11.        "U11 ,User Mode 11 Enable" "Disabled,Enabled"
bitfld.long 0x00 10. "       U10 ,User Mode 10 Enable" "Disabled,Enabled"
bitfld.long 0x00 9.  "       U9  ,User Mode 9 Enable"  "Disabled,Enabled"
bitfld.long 0x00 8.  "       U8  ,User Mode 8 Enable"  "Disabled,Enabled"
newline
bitfld.long 0x00 7.         "U7  ,User Mode 7 Enable"  "Disabled,Enabled"
bitfld.long 0x00 6.  "       U6  ,User Mode 6 Enable"  "Disabled,Enabled"
bitfld.long 0x00 5.  "       U5  ,User Mode 5 Enable"  "Disabled,Enabled"
bitfld.long 0x00 4.  "       U4  ,User Mode 4 Enable"  "Disabled,Enabled"
newline
bitfld.long 0x00 3.         "U3  ,User Mode 3 Enable"  "Disabled,Enabled"
bitfld.long 0x00 2.  "       U2  ,User Mode 2 Enable"  "Disabled,Enabled"
bitfld.long 0x00 1.  "       U1  ,User Mode 1 Enable"  "Disabled,Enabled"
bitfld.long 0x00 0.  "       U0  ,User Mode 0 Enable"  "Disabled,Enabled"
newline
group.long aux:0x20A++0
line.long 0x00 "DMP_PERIPHERAL,Peripheral Memory Region"
TREE.END
SIF ((data.long(aux:0x75)&0xFF)!=0)&&((data.long(aux:0x75)&0x300)!=0)
CONFIG 36.
WIDTH  18.
TREE   "Timer"
; Auxiliary Timer Register
sif ((data.long(aux:0x75)&0xFF)!=0)&&((data.long(aux:0x75)&0x100)!=0)
group.long aux:0x21++0
line.long 0x00 "COUNT0,Timer 0 Count Register"
hexmask.long 0x00 0.--31. 1. "TCV ,Timer Count Value"
group.long aux:0x22++0
line.long 0x00 "CONTROL0,Timer 0 Control Register"
bitfld.long 0x00 0. "IE  ,Interrupt Enable" "Disabled,Enabled"
bitfld.long 0x00 1. "         NH  ,Not Halted Mode Flag" "Count Always,Count when not Halted"
bitfld.long 0x00 2. "  W ,Watchdog Mode Flag Enable" "Disabled,Enabled"
bitfld.long 0x00 3. "  IP ,Interrupt Pending Flag" "Not pending,Pending"
group.long aux:0x23++0
line.long 0x00 "LIMIT0,Timer 0 Limit Register"
hexmask.long 0x00 0.--31. 1. "TLV ,Timer Limit Value"
endif
sif ((data.long(aux:0x75)&0xFF)!=0)&&((data.long(aux:0x75)&0x200)!=0)
textline ""
group.long aux:0x100++0
line.long 0x00 "COUNT1,Timer 1 Count Register"
hexmask.long 0x00 0.--31. 1. "TCV ,Timer Count Value"
group.long aux:0x101++0
line.long 0x00 "CONTROL1,Timer 1 Control Register"
bitfld.long 0x00 0. "IE  ,Interrupt Enable" "Disabled,Enabled"
bitfld.long 0x00 1. "         NH  ,Not Halted Mode Flag" "Count Always,Count when not Halted"
bitfld.long 0x00 2. "  W ,Watchdog Mode Flag Enable" "Disabled,Enabled"
bitfld.long 0x00 3. "  IP ,Interrupt Pending Flag" "Not pending,Pending"
group.long aux:0x102++0
line.long 0x00 "LIMIT1,Timer 1 Limit Register"
hexmask.long 0x00 0.--31. 1. "TLV ,Timer Limit Value"
endif
TREE.END
ENDIF
SIF CORETYPE()<811.
TREE "Interrupts & Exceptions"
width 20.
; Auxiliary Register for Interrupts & Exceptions
group.long aux:0x25++0
line.long 0x00 "INT_VECTOR_BASE,Interrupt Vector Base Register"
hexmask.long 0x00 10.--31. 0x400 " INT_VECTOR_BASE ,Interrupt Vector Base Address"
group.long aux:0x43++0
line.long 0x00 "AUX_IRQ_LV12,Interrupt Level Status Register"
eventfld.long 0x00 1. " L2      ,Level 2 Interrupt" "-,occurred"
eventfld.long 0x00 0. "     L1      ,Level 1 Interrupt" "-,occurred"
sif (coretype()>=700.)
group.long aux:0x201++0
line.long 0x00 "AUX_IRQ_HINT,Software Interrupt Trigger Register"
bitfld.long 0x00 0.--4. " IRQNO   ,Value of the Current Software Triggered Interrupt" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
rgroup.long aux:0x416++0
line.long 0x00 "AUX_IRQ_PENDING,Interrupt Pending Register"
bitfld.long 0x00 31. " IRQ31   ,Interrupt Pending 31" "Not pending,Pending"
bitfld.long 0x00 30. "  IRQ30   ,Interrupt Pending 30" "Not pending,Pending"
bitfld.long 0x00 29. "  IRQ29   ,Interrupt Pending 29" "Not pending,Pending"
bitfld.long 0x00 28. "  IRQ28   ,Interrupt Pending 28" "Not pending,Pending"
textline "                            "
bitfld.long 0x00 27. "  IRQ27   ,Interrupt Pending 27" "Not pending,Pending"
bitfld.long 0x00 26. "  IRQ26   ,Interrupt Pending 26" "Not pending,Pending"
bitfld.long 0x00 25. "  IRQ25   ,Interrupt Pending 25" "Not pending,Pending"
bitfld.long 0x00 24. "  IRQ24   ,Interrupt Pending 24" "Not pending,Pending"
textline "                            "
bitfld.long 0x00 23. "  IRQ23   ,Interrupt Pending 23" "Not pending,Pending"
bitfld.long 0x00 22. "  IRQ22   ,Interrupt Pending 22" "Not pending,Pending"
bitfld.long 0x00 21. "  IRQ21   ,Interrupt Pending 21" "Not pending,Pending"
bitfld.long 0x00 20. "  IRQ20   ,Interrupt Pending 20" "Not pending,Pending"
textline "                            "
bitfld.long 0x00 19. "  IRQ19   ,Interrupt Pending 19" "Not pending,Pending"
bitfld.long 0x00 18. "  IRQ18   ,Interrupt Pending 18" "Not pending,Pending"
bitfld.long 0x00 17. "  IRQ17   ,Interrupt Pending 17" "Not pending,Pending"
bitfld.long 0x00 16. "  IRQ16   ,Interrupt Pending 16" "Not pending,Pending"
textline "                            "
bitfld.long 0x00 15. "  IRQ15   ,Interrupt Pending 15" "Not pending,Pending"
bitfld.long 0x00 14. "  IRQ14   ,Interrupt Pending 14" "Not pending,Pending"
bitfld.long 0x00 13. "  IRQ13   ,Interrupt Pending 13" "Not pending,Pending"
bitfld.long 0x00 12. "  IRQ12   ,Interrupt Pending 12" "Not pending,Pending"
textline "                            "
bitfld.long 0x00 11. "  IRQ11   ,Interrupt Pending 11" "Not pending,Pending"
bitfld.long 0x00 10. "  IRQ10   ,Interrupt Pending 10" "Not pending,Pending"
bitfld.long 0x00  9. "  IRQ9    ,Interrupt Pending 9"  "Not pending,Pending"
bitfld.long 0x00  8. "  IRQ8    ,Interrupt Pending 8"  "Not pending,Pending"
textline "                            "
bitfld.long 0x00  7. "  IRQ7    ,Interrupt Pending 7"  "Not pending,Pending"
bitfld.long 0x00  6. "  IRQ6    ,Interrupt Pending 6"  "Not pending,Pending"
bitfld.long 0x00  5. "  IRQ5    ,Interrupt Pending 5"  "Not pending,Pending"
bitfld.long 0x00  4. "  IRQ4    ,Interrupt Pending 4"  "Not pending,Pending"
textline "                            "
bitfld.long 0x00  3. "  IRQ3    ,Interrupt Pending 3"  "Not pending,Pending"
group.long aux:0x40c++0
line.long 0x00 "AUX_IENABLE,Interrupt Mask Programming Register"
bitfld.long 0x00 31. " IRQ31   ,Interrupt 31 Enable" "Disabled,Enabled"
bitfld.long 0x00 30. "     IRQ30   ,Interrupt 30 Enable" "Disabled,Enabled"
bitfld.long 0x00 29. "     IRQ29   ,Interrupt 29 Enable" "Disabled,Enabled"
bitfld.long 0x00 28. "     IRQ28   ,Interrupt 28 Enable" "Disabled,Enabled"
textline "                         "
bitfld.long 0x00 27. "     IRQ27   ,Interrupt 27 Enable" "Disabled,Enabled"
bitfld.long 0x00 26. "     IRQ26   ,Interrupt 26 Enable" "Disabled,Enabled"
bitfld.long 0x00 25. "     IRQ25   ,Interrupt 25 Enable" "Disabled,Enabled"
bitfld.long 0x00 24. "     IRQ24   ,Interrupt 24 Enable" "Disabled,Enabled"
textline "                         "
bitfld.long 0x00 23. "     IRQ23   ,Interrupt 23 Enable" "Disabled,Enabled"
bitfld.long 0x00 22. "     IRQ22   ,Interrupt 22 Enable" "Disabled,Enabled"
bitfld.long 0x00 21. "     IRQ21   ,Interrupt 21 Enable" "Disabled,Enabled"
bitfld.long 0x00 20. "     IRQ20   ,Interrupt 20 Enable" "Disabled,Enabled"
textline "                         "
bitfld.long 0x00 19. "     IRQ19   ,Interrupt 19 Enable" "Disabled,Enabled"
bitfld.long 0x00 18. "     IRQ18   ,Interrupt 18 Enable" "Disabled,Enabled"
bitfld.long 0x00 17. "     IRQ17   ,Interrupt 17 Enable" "Disabled,Enabled"
bitfld.long 0x00 16. "     IRQ16   ,Interrupt 16 Enable" "Disabled,Enabled"
textline "                         "
bitfld.long 0x00 15. "     IRQ15   ,Interrupt 15 Enable" "Disabled,Enabled"
bitfld.long 0x00 14. "     IRQ14   ,Interrupt 14 Enable" "Disabled,Enabled"
bitfld.long 0x00 13. "     IRQ13   ,Interrupt 13 Enable" "Disabled,Enabled"
bitfld.long 0x00 12. "     IRQ12   ,Interrupt 12 Enable" "Disabled,Enabled"
textline "                         "
bitfld.long 0x00 11. "     IRQ11   ,Interrupt 11 Enable" "Disabled,Enabled"
bitfld.long 0x00 10. "     IRQ10   ,Interrupt 10 Enable" "Disabled,Enabled"
bitfld.long 0x00 9.  "     IRQ9    ,Interrupt 9 Enable"  "Disabled,Enabled"
bitfld.long 0x00 8.  "     IRQ8    ,Interrupt 8 Enable"  "Disabled,Enabled"
textline "                         "
bitfld.long 0x00 7.  "     IRQ7    ,Interrupt 7 Enable"  "Disabled,Enabled"
bitfld.long 0x00 6.  "     IRQ6    ,Interrupt 6 Enable"  "Disabled,Enabled"
bitfld.long 0x00 5.  "     IRQ5    ,Interrupt 5 Enable"  "Disabled,Enabled"
bitfld.long 0x00 4.  "     IRQ4    ,Interrupt 4 Enable"  "Disabled,Enabled"
textline "                         "
bitfld.long 0x00 3.  "     IRQ3    ,Interrupt 3 Enable"  "Disabled,Enabled"
endif
sif (coretype()>=500.)
group.long aux:0x200++0
line.long 0x00 "AUX_IRQ_LEV,Interrupt Level Programming Register"
bitfld.long 0x00 31. " IRQ31   ,Interrupt 31 Enable" "level 1,level 2"
bitfld.long 0x00 30. "      IRQ30   ,Interrupt 30 Enable" "level 1,level 2"
bitfld.long 0x00 29. "      IRQ29   ,Interrupt 29 Enable" "level 1,level 2"
bitfld.long 0x00 28. "      IRQ28   ,Interrupt 28 Enable" "level 1,level 2"
textline "                        "
bitfld.long 0x00 27. "      IRQ27   ,Interrupt 27 Enable" "level 1,level 2"
bitfld.long 0x00 26. "      IRQ26   ,Interrupt 26 Enable" "level 1,level 2"
bitfld.long 0x00 25. "      IRQ25   ,Interrupt 25 Enable" "level 1,level 2"
bitfld.long 0x00 24. "      IRQ24   ,Interrupt 24 Enable" "level 1,level 2"
textline "                        "
bitfld.long 0x00 23. "      IRQ23   ,Interrupt 23 Enable" "level 1,level 2"
bitfld.long 0x00 22. "      IRQ22   ,Interrupt 22 Enable" "level 1,level 2"
bitfld.long 0x00 21. "      IRQ21   ,Interrupt 21 Enable" "level 1,level 2"
bitfld.long 0x00 20. "      IRQ20   ,Interrupt 20 Enable" "level 1,level 2"
textline "                        "
bitfld.long 0x00 19. "      IRQ19   ,Interrupt 19 Enable" "level 1,level 2"
bitfld.long 0x00 18. "      IRQ18   ,Interrupt 18 Enable" "level 1,level 2"
bitfld.long 0x00 17. "      IRQ17   ,Interrupt 17 Enable" "level 1,level 2"
bitfld.long 0x00 16. "      IRQ16   ,Interrupt 16 Enable" "level 1,level 2"
textline "                        "
bitfld.long 0x00 15. "      IRQ15   ,Interrupt 15 Enable" "level 1,level 2"
bitfld.long 0x00 14. "      IRQ14   ,Interrupt 14 Enable" "level 1,level 2"
bitfld.long 0x00 13. "      IRQ13   ,Interrupt 13 Enable" "level 1,level 2"
bitfld.long 0x00 12. "      IRQ12   ,Interrupt 12 Enable" "level 1,level 2"
textline "                        "
bitfld.long 0x00 11. "      IRQ11   ,Interrupt 11 Enable" "level 1,level 2"
bitfld.long 0x00 10. "      IRQ10   ,Interrupt 10 Enable" "level 1,level 2"
bitfld.long 0x00 9.  "      IRQ9    ,Interrupt 9 Enable"  "level 1,level 2"
bitfld.long 0x00 8.  "      IRQ8    ,Interrupt 8 Enable"  "level 1,level 2"
textline "                        "
bitfld.long 0x00 7.  "      IRQ7    ,Interrupt 7 Enable"  "level 1,level 2"
bitfld.long 0x00 6.  "      IRQ6    ,Interrupt 6 Enable"  "level 1,level 2"
bitfld.long 0x00 5.  "      IRQ5    ,Interrupt 5 Enable"  "level 1,level 2"
bitfld.long 0x00 4.  "      IRQ4    ,Interrupt 4 Enable"  "level 1,level 2"
textline "                        "
bitfld.long 0x00 3.  "      IRQ3    ,Interrupt 3 Enable"  "level 1,level 2"
endif
sif (coretype()>=700.)
group.long aux:0x40d++0
line.long 0x00 "AUX_ITRIGGER,Interrupt Sensitivity Programming Register"
bitfld.long 0x00 31. " IRQ31   ,Interrupt 31 Sensitivity" "Level,Pulse"
bitfld.long 0x00 30. "        IRQ30   ,Interrupt 30 Sensitivity" "Level,Pulse"
bitfld.long 0x00 29. "        IRQ29   ,Interrupt 29 Sensitivity" "Level,Pulse"
bitfld.long 0x00 28. "        IRQ28   ,Interrupt 28 Sensitivity" "Level,Pulse"
textline "                      "
bitfld.long 0x00 27. "        IRQ27   ,Interrupt 27 Sensitivity" "Level,Pulse"
bitfld.long 0x00 26. "        IRQ26   ,Interrupt 26 Sensitivity" "Level,Pulse"
bitfld.long 0x00 25. "        IRQ25   ,Interrupt 25 Sensitivity" "Level,Pulse"
bitfld.long 0x00 24. "        IRQ24   ,Interrupt 24 Sensitivity" "Level,Pulse"
textline "                      "
bitfld.long 0x00 23. "        IRQ23   ,Interrupt 23 Sensitivity" "Level,Pulse"
bitfld.long 0x00 22. "        IRQ22   ,Interrupt 22 Sensitivity" "Level,Pulse"
bitfld.long 0x00 21. "        IRQ21   ,Interrupt 21 Sensitivity" "Level,Pulse"
bitfld.long 0x00 20. "        IRQ20   ,Interrupt 20 Sensitivity" "Level,Pulse"
textline "                      "
bitfld.long 0x00 19. "        IRQ19   ,Interrupt 19 Sensitivity" "Level,Pulse"
bitfld.long 0x00 18. "        IRQ18   ,Interrupt 18 Sensitivity" "Level,Pulse"
bitfld.long 0x00 17. "        IRQ17   ,Interrupt 17 Sensitivity" "Level,Pulse"
bitfld.long 0x00 16. "        IRQ16   ,Interrupt 16 Sensitivity" "Level,Pulse"
textline "                      "
bitfld.long 0x00 15. "        IRQ15   ,Interrupt 15 Sensitivity" "Level,Pulse"
bitfld.long 0x00 14. "        IRQ14   ,Interrupt 14 Sensitivity" "Level,Pulse"
bitfld.long 0x00 13. "        IRQ13   ,Interrupt 13 Sensitivity" "Level,Pulse"
bitfld.long 0x00 12. "        IRQ12   ,Interrupt 12 Sensitivity" "Level,Pulse"
textline "                      "
bitfld.long 0x00 11. "        IRQ11   ,Interrupt 11 Sensitivity" "Level,Pulse"
bitfld.long 0x00 10. "        IRQ10   ,Interrupt 10 Sensitivity" "Level,Pulse"
bitfld.long 0x00 9.  "        IRQ9    ,Interrupt 9 Sensitivity"  "Level,Pulse"
bitfld.long 0x00 8.  "        IRQ8    ,Interrupt 8 Sensitivity"  "Level,Pulse"
textline "                      "
bitfld.long 0x00 7.  "        IRQ7    ,Interrupt 7 Sensitivity"  "Level,Pulse"
bitfld.long 0x00 6.  "        IRQ6    ,Interrupt 6 Sensitivity"  "Level,Pulse"
bitfld.long 0x00 5.  "        IRQ5    ,Interrupt 5 Sensitivity"  "Level,Pulse"
bitfld.long 0x00 4.  "        IRQ4    ,Interrupt 4 Sensitivity"  "Level,Pulse"
textline "                      "
bitfld.long 0x00 3.  "        IRQ3    ,Interrupt 3 Sensitivity"  "Level,Pulse"
wgroup.long aux:0x415++0
hide.long 0x00 "AUX_IRQ_PULSE_CANCEL,Interrupt Pulse Cancel Register"
button "Clear Pulse 31" "per.s aux:0x415 %LONG 0x80000000"
textfld "  "
button "Clear Pulse 30" "per.s aux:0x415 %LONG 0x40000000"
textfld "  "
button "Clear Pulse 29" "per.s aux:0x415 %LONG 0x20000000"
textfld "  "
button "Clear Pulse 28" "per.s aux:0x415 %LONG 0x10000000"
textline "                             "
button "Clear Pulse 27" "per.s aux:0x415 %LONG 0x08000000"
textfld "  "
button "Clear Pulse 26" "per.s aux:0x415 %LONG 0x04000000"
textfld "  "
button "Clear Pulse 25" "per.s aux:0x415 %LONG 0x02000000"
textfld "  "
button "Clear Pulse 24" "per.s aux:0x415 %LONG 0x01000000"
textline "                             "
button "Clear Pulse 23" "per.s aux:0x415 %LONG 0x00800000"
textfld "  "
button "Clear Pulse 22" "per.s aux:0x415 %LONG 0x00400000"
textfld "  "
button "Clear Pulse 21" "per.s aux:0x415 %LONG 0x00200000"
textfld "  "
button "Clear Pulse 20" "per.s aux:0x415 %LONG 0x00100000"
textline "                             "
button "Clear Pulse 19" "per.s aux:0x415 %LONG 0x00080000"
textfld "  "
button "Clear Pulse 18" "per.s aux:0x415 %LONG 0x00040000"
textfld "  "
button "Clear Pulse 17" "per.s aux:0x415 %LONG 0x00020000"
textfld "  "
button "Clear Pulse 16" "per.s aux:0x415 %LONG 0x00010000"
textline "                             "
button "Clear Pulse 15" "per.s aux:0x415 %LONG 0x00008000"
textfld "  "
button "Clear Pulse 14" "per.s aux:0x415 %LONG 0x00004000"
textfld "  "
button "Clear Pulse 13" "per.s aux:0x415 %LONG 0x00002000"
textfld "  "
button "Clear Pulse 12" "per.s aux:0x415 %LONG 0x00001000"
textline "                             "
button "Clear Pulse 11" "per.s aux:0x415 %LONG 0x00000800"
textfld "  "
button "Clear Pulse 10" "per.s aux:0x415 %LONG 0x00000400"
textfld "  "
button "Clear Pulse  9" "per.s aux:0x415 %LONG 0x00000200"
textfld "  "
button "Clear Pulse  8" "per.s aux:0x415 %LONG 0x00000100"
textline "                             "
button "Clear Pulse  7" "per.s aux:0x415 %LONG 0x00000080"
textfld "  "
button "Clear Pulse  6" "per.s aux:0x415 %LONG 0x00000040"
textfld "  "
button "Clear Pulse  5" "per.s aux:0x415 %LONG 0x00000020"
textfld "  "
button "Clear Pulse  4" "per.s aux:0x415 %LONG 0x00000010"
textline "                             "
button "Clear Pulse  3" "per.s aux:0x415 %LONG 0x00000008"
textfld "                     "
button "Clear Mem.Err." "per.s aux:0x415 %LONG 0x00000002"
endif
sif (coretype()>=500.)
textline ""
sif (coretype()>=700.)
group.long aux:0x40a++0
line.long 0x00 "ICAUSE1,Interrupt Cause 1 Register"
bitfld.long 0x00 0.--4. " ICAUSE  ,Number of the Interrupt Being Handled" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
endif
group.long aux:0x0b++0
line.long 0x00 "STATUS32_L1,Interrupt Status Link 1 Register"
bitfld.long 0x00 11. " Z       ,Zero Flag" "Not zero,Zero"
bitfld.long 0x00 10. "     N  ,Negative Flag" "Not negative,Negative"
bitfld.long 0x00 9.  "  C  ,Carry Flag" "No carry,Carry"
bitfld.long 0x00 8.  "     V  ,Overflow Flag" "No overflow,Overflow"
textline "                              "
bitfld.long 0x00 2.  "E2      ,Interrupt Mask E2" "Disabled,Enabled"
bitfld.long 0x00 1.  "     E1 ,Interrupt Mask E2" "Disabled,Enabled"
sif (coretype()>=700.)
textline "                              "
bitfld.long 0x00 4.  "A2      ,Level 2 Interrupt Active" "-,Active"
bitfld.long 0x00 3.  "       A1 ,Level 1 Interrupt Active" "-,Active"
bitfld.long 0x00 5.  "        AE ,Exception Active" "-,Active"
textline "                              "
bitfld.long 0x00 7.  "U       ,User Mode" "Kernel,User"
bitfld.long 0x00 12. "       L  ,Zero-Overhead Loop Mechanism" "Enabled,Disabled"
bitfld.long 0x00 6.  "      DE ,Delay Slot Instruction Flag" "-,Delay Slot"
sif (coretype()>=800.)
bitfld.long 0x00 13.  "   DZ ,EV_DivZero exception" "Disabled,Enabled"
else
bitfld.long 0x00 14.  "   SE ,Stack Checking" "Disabled,Enabled"
endif
endif
sif ((coretype()>=700.)&&((data.long(aux:0x63)&1)==1))
group.long aux:0x413++0
line.long 0x00 "BTA_L1,Interrupt Branch Target Link 1 Register"
hexmask.long 0x00 1.--31. 2. " ADDRESS ,Interrupt Branch Target Link"
bitfld.long 0x00 0. "     T  ,Take Branch" "don't branch,take branch"
endif
endif
sif (coretype()>=500.)
textline ""
sif (coretype()>=700.)
group.long aux:0x40b++0
line.long 0x00 "ICAUSE2,Interrupt Cause 2 Register"
bitfld.long 0x00 0.--4. " ICAUSE  ,Number of the Interrupt Being Handled" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
endif
group.long aux:0x0c++0
line.long 0x00 "STATUS32_L2,Interrupt Status Link 2 Register"
bitfld.long 0x00 11. " Z       ,Zero Flag" "Not zero,Zero"
bitfld.long 0x00 10. "     N  ,Negative Flag" "Not negative,Negative"
bitfld.long 0x00 9.  "  C  ,Carry Flag" "No carry,Carry"
bitfld.long 0x00 8.  "     V  ,Overflow Flag" "No overflow,Overflow"
textline "                              "
bitfld.long 0x00 2.  "E2      ,Interrupt Mask E2" "Disabled,Enabled"
bitfld.long 0x00 1.  "     E1 ,Interrupt Mask E2" "Disabled,Enabled"
sif (coretype()>=700.)
textline "                              "
bitfld.long 0x00 4.  "A2      ,Level 2 Interrupt Active" "-,Active"
bitfld.long 0x00 3.  "       A1 ,Level 1 Interrupt Active" "-,Active"
bitfld.long 0x00 5.  "        AE ,Exception Active" "-,Active"
textline "                              "
bitfld.long 0x00 7.  "U       ,User Mode" "Kernel,User"
bitfld.long 0x00 12. "       L  ,Zero-Overhead Loop Mechanism" "Enabled,Disabled"
bitfld.long 0x00 6.  "      DE ,Delay Slot Instruction Flag" "-,Delay Slot"
sif (coretype()>=800.)
bitfld.long 0x00 13.  "   DZ ,EV_DivZero exception" "Disabled,Enabled"
else
bitfld.long 0x00 14.  "   SE ,Stack Checking" "Disabled,Enabled"
endif
endif
sif ((coretype()>=700.)&&((data.long(aux:0x63)&1)==1))
group.long aux:0x414++0
line.long 0x00 "BTA_L2,Interrupt Branch Target Link 2 Register"
hexmask.long 0x00 1.--31. 2. " ADDRESS ,Interrupt Branch Target Link"
bitfld.long 0x00 0. "     T  ,Take Branch" "don't branch,take branch"
endif
endif
sif (coretype()>=700.)
textline ""
group.long aux:0x403++0
line.long 0x00 "ECR,Exception Cause Register"
hexmask.long.byte 0x00 16.--23. 1. " VN      ,Vector Number"
hexmask.long.byte 0x00 8.--15. 1. "           CC ,Cause Code"
hexmask.long.byte 0x00 0.--7. 1. "          PAR  ,Parameter"
group.long aux:0x402++0
line.long 0x00 "ERSTATUS,Exception Return Status"
bitfld.long 0x00 11. " Z       ,Zero Flag" "Not zero,Zero"
bitfld.long 0x00 10. "     N  ,Negative Flag" "Not negative,Negative"
bitfld.long 0x00 9.  "  C  ,Carry Flag" "No carry,Carry"
bitfld.long 0x00 8.  "     V  ,Overflow Flag" "No overflow,Overflow"
textline "                              "
bitfld.long 0x00 2.  "E2      ,Interrupt Mask E2" "Disabled,Enabled"
bitfld.long 0x00 1.  "     E1 ,Interrupt Mask E2" "Disabled,Enabled"
sif (coretype()>=700.)
textline "                              "
bitfld.long 0x00 4.  "A2      ,Level 2 Interrupt Active" "-,Active"
bitfld.long 0x00 3.  "       A1 ,Level 1 Interrupt Active" "-,Active"
bitfld.long 0x00 5.  "        AE ,Exception Active" "-,Active"
textline "                              "
bitfld.long 0x00 7.  "U       ,User Mode" "Kernel,User"
bitfld.long 0x00 12. "       L  ,Zero-Overhead Loop Mechanism" "Enabled,Disabled"
bitfld.long 0x00 6.  "      DE ,Delay Slot Instruction Flag" "-,Delay Slot"
sif (coretype()>=800.)
bitfld.long 0x00 13.  "   DZ ,EV_DivZero exception" "Disabled,Enabled"
else
bitfld.long 0x00 14.  "   SE ,Stack Checking" "Disabled,Enabled"
endif
endif
sif ((data.long(aux:0x63)&1)==1)||(coretype()>=800.)
group.long aux:0x401++0
line.long 0x00 "ERBTA,Exception Return Branch Target Address Register"
hexmask.long 0x00 1.--31. 2. " ADDRESS ,Exception Return Branch Target Address"
bitfld.long 0x00 0. "     T  ,Take Branch" "don't branch,take branch"
endif
group.long aux:0x404++0
line.long 0x00 "EFA,Exception Fault Address Register"
hexmask.long 0x00 0.--31. 1. " ADDRESS ,Exception Fault Address"
group.long aux:0x400++0
line.long 0x00 "ERET,Exception Return Address Register"
hexmask.long 0x00 1.--31. 2. " ADDRESS ,Exception Return Address"
endif

TREE.END
ENDIF
SIF ((DATA.LONG(AUX:0x78)&0xff)>0)||((DATA.LONG(AUX:0x74)&0xff)>0)
CONFIG 36.
WIDTH  18.
TREE   "Closely Coupled Memory"
SIF (DATA.LONG(AUX:0x78)&0xff)>0
rgroup.long aux:0x78++0 "ICCM"
line.long 0x00 "ICCM_BUILD,ICCM Configuration Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERS.,Current Version"
sgroup
GETX aux:0x78 %Long 4
VARX 0 %Byte ((PER.B.L(4)>>8.)&0x0f)+((PER.B.L(4)>>16.)&0x0f)
VARX 1 %Byte ((PER.B.L(4)>>12.)&0x0f)+((PER.B.L(4)>>20.)&0x0f)
bitfld.byte 0x00 0.--7. "   ICCM0_SIZE ,Size of ICCM0 RAM"       "0,0.5KiB,1.KiB,2.KiB,4.KiB,8.KiB,16.KiB,32.KiB,64.KiB,128.KiB,256.KiB,512.KiB,1.MiB,2.MiB,4.MiB,8.MiB,16.MiB,32.MiB,64.MiB,128.MiB,256.MiB,512MiB,?..."
bitfld.byte 0x01 0.--7. "   ICCM1_SIZE ,Size of ICCM1 RAM"       "0,0.5KiB,1.KiB,2.KiB,4.KiB,8.KiB,16.KiB,32.KiB,64.KiB,128.KiB,256.KiB,512.KiB,1.MiB,2.MiB,4.MiB,8.MiB,16.MiB,32.MiB,64.MiB,128.MiB,256.MiB,512MiB,?..."
sif coretype()<900.
bitfld.long 0x04 24.--27. "   NVM_SIZE ,Size of non-volatile ICCM" "0,0.5KiB,1.KiB,2.KiB,4.KiB,8.KiB,16.KiB,32.KiB,64.KiB,128.KiB,256.KiB,512.KiB,1.MiB,2.MiB,4.MiB,8.MiB"
bitfld.long 0x04 28.--28. " NI ,NV_ICCM implementation" "no FIQ,for FIQ"
endif
group.long aux:0x208++0
line.long 0x00 "AUX_ICCM,ICCM base address"
sif ((DATA.LONG(AUX:0x78)>>12.)&0x0f)==0
;ICCM 0 only
hexfld.long 0x00 "          ICCM0_base "
else
sgroup
CONSTX 0x0C %Long 0x0f<<(12.+4*((data.long(AUX:0xc1)>>16.)&0x0f))
GETX aux:0x208 %Long 0x08
VARX   0x00 %Long PER.B.L(0x08)&PER.B.L(0x0C)
VARX   0x04 %Long (PER.B.L(0x08)<<4)&PER.B.L(0x0C)
WRITEBACK
VARX   0x08 %Long  PER.B.L(0x00)|(PER.B.L(0x04)>>4)
SETX aux:0x208 %Long 0x08
newline
hexfld.long 0x00 "          ICCM0_base ,ICCM0 base address"
hexfld.long 0x04 "  ICCM1_base ,ICCM1 base address"
endif
ENDIF
SIF (DATA.LONG(AUX:0x74)&0xff)>0
rgroup.long aux:0x74++0 "DCCM"
line.long 0x00 "DCCM_BUILD,DCCM Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERS.,Current Version"
sgroup
GETX AUX:0x74 %Long 4
VARX 0 %Byte ((PER.B.L(4)>>8.)&0x0f)+((PER.B.L(4)>>12.)&0x0f)
bitfld.byte 0x00 0.--7. "    DCCM_SIZE ,Size of DCCM RAM"   "0,0.5KiB,1.KiB,2.KiB,4.KiB,8.KiB,16.KiB,32.KiB,64.KiB,128.KiB,256.KiB,512.KiB,1.MiB,2.MiB,4.MiB,8.MiB,16.MiB,32.MiB,64.MiB,128.MiB,256.MiB,512MiB,?..."
sif coretype()>=900.
sif (data.long(AUX:0x74)&0xff)>=4.
hexmask.long.byte 0x04 17.--19. 1 "   Cycles ,n-cycle memory"
endif
bitfld.long 0x04 20.--20. "   DPW ,Support of partial writes through DMI interface" "no,yes"
else
bitfld.long 0x04 16.--16. "   IL ,Support interleaving" "no,yes"
endif
group.long aux:0x18++0
line.long 0x00 "AUX_DCCM,DCCM base address"
hexfld.long 0x00 "           DCCM_base "
ENDIF
TREE.END
ENDIF

SIF (DATA.LONG(AUX:0x6D)&0xff)>0
CONFIG 36.
WIDTH  18.
TREE   "Memory Protection Unit MPU"
Rgroup.long aux:0x6D++0
line.long 0x00 "MPU_BUILD,Memory Protection Build Register"
hexmask.long.word 0x00 00.--07. 1 "VERSION  ,Current Version"
decmask.long.byte 0x00 08.--15. 1 "  Regions,Number of regions supported"
textfld "."
sif (Data.Long(AUX:0x6D)&0xff)>=4
bitfld.long 0x00 16. "     S , Supports secure regions" "-,supported"
bitfld.long 0x00 17. "      I  , Supports SID mechanism"        "-,supported"
endif
group.long aux:0x409++0
line.long 0x00 "MPU_EN,MPU Enable Register"
textfld     "Perms   R W X          R W X"
sif ((Data.Long(AUX:0x6D)&0xff)>=4)&&(((Data.Long(AUX:0x6D)>>16.)&1)==1)
bitfld.long 0x00 15.--15. "    S , Supports secure regions" "none-secure,secure"
endif
sif ((Data.Long(AUX:0x6D)&0xff)>=4)&&(((Data.Long(AUX:0x6D)>>17.)&1)==1)
hexmask.long.byte 0x00 16.--23. 1 "   SID "
endif
newline
textfld "General"
bitfld.long 0x00 05. " ,General Read Permission"        "-,R"
bitfld.long 0x00 04. " ,General Write Permission"       "-,W"
bitfld.long 0x00 03. " ,General Execute Permission"     "-,X"
textfld "   Kernel"
bitfld.long 0x00 08. " ,Kernel-only Read Permission"    "-,R"
bitfld.long 0x00 07. " ,Kernel-only Write Permission"   "-,W"
bitfld.long 0x00 06. " ,Kernel-only Execute Permission" "-,X"
bitfld.long 0x00 30. "   EN , MPU enable bit" "disabled,enabled"
Rgroup.long aux:0x420++0
line.long 0x00 "MPU_ECR,MPU exception cause register"
decmask.long.byte 0x00 00.--07. 1 "MR   ,MPU Region"
textfld "."
bitfld.long       0x00 08.--09.   "  VT ,Violation Type"    "Execution,Read,Write,ReadModWrite"
bitfld.long       0x00 10.--10.   "   SEC ,Secure Violation" "-,Secure viol."
bitfld.long       0x00 11.--11.   "  SID ,SID mismatch"     "-,SID mismatch"
hexmask.long.word 0x00 16.--31. 1 "  EC_CODE ,Exception Vector"
SIF ((Data.Long(AUX:0x6D)&0xff)>=4)&&(((Data.Long(AUX:0x6D)>>16.)&1)==1)
// Secure Memory Protection Unit
group.long aux:0x448++3
line.long 0x00 "MPU_INDEX,MPU Index Register"
decmask.long.byte 0x00 00.--03. 1 "Index,Region Index"
textfld "."
rbitfld.long      0x00 30. "   M ,multiple regions"  "-,multiple"
rbitfld.long      0x00 31. "         D ,default region"    "-,default"
line.long 0x04 "MPU_RSTART,MPU Region Start Address Register"
hexmask.long.long 0x04 05.--31. 32.  "Start ,Start Address"
line.long 0x08 "MPU_REND,MPU Region End Address Register"
hexmask.long.long 0x08 05.--31. 32.  "End   ,End Address"
line.long 0x0C "MPU_RPER,MPU Region Permission Register"
textfld     "Perms   R W X          R W X"
bitfld.long 0x0C 15. "    S , Supports secure regions" "none-secure,secure"
sif ((Data.Long(AUX:0x6D)&0xff)>=4)&&(((Data.Long(AUX:0x6D)>>17.)&1)==1)
hexmask.long.byte 0x0C 16.--23. 1 "   SID "
endif
newline
textfld "General"
bitfld.long 0x0C 05. " ,General Read Permission"        "-,R"
bitfld.long 0x0C 04. " ,General Write Permission"       "-,W"
bitfld.long 0x0C 03. " ,General Execute Permission"     "-,X"
textfld "   Kernel"
bitfld.long 0x0C 08. " ,Kernel-only Read Permission"    "-,R"
bitfld.long 0x0C 07. " ,Kernel-only Write Permission"   "-,W"
bitfld.long 0x0C 06. " ,Kernel-only Execute Permission" "-,X"
bitfld.long 0x0C 00. "    V ,Region valid descriptor" "unused,Valid"
Wgroup.long aux:0x44C++0
line.long 0x00 "MPU_PROBE,MPU Probe Register"
TREE  "Regions"
WIDTH  16.
group.long aux:0x449++2 "Secure MPU region 0."
INDEX AUX:0x448 %Long 0 0
line.long 0x00 "MPU_RSTART,MPU Region Start Address Register"
hexmask.long.long 0x00 05.--31. 32.  "Start ,Start Address"
line.long 0x04 "MPU_REND,MPU Region End Address Register"
hexmask.long.long 0x04 05.--31. 32.  "End   ,End Address"
line.long 0x08 "MPU_RPER,MPU Region Permission Register"
textfld     "Perms   R W X          R W X"
bitfld.long 0x08 15. "    S , Supports secure regions" "none-secure,secure"
sif ((Data.Long(AUX:0x6D)&0xff)>=4)&&(((Data.Long(AUX:0x6D)>>17.)&1)==1)
hexmask.long.byte 0x08 16.--23. 1 "   SID "
endif
newline
textfld "General"
bitfld.long 0x08 05. " ,General Read Permission"        "-,R"
bitfld.long 0x08 04. " ,General Write Permission"       "-,W"
bitfld.long 0x08 03. " ,General Execute Permission"     "-,X"
textfld "   Kernel"
bitfld.long 0x08 08. " ,Kernel-only Read Permission"    "-,R"
bitfld.long 0x08 07. " ,Kernel-only Write Permission"   "-,W"
bitfld.long 0x08 06. " ,Kernel-only Execute Permission" "-,X"
bitfld.long 0x08 00. "    V ,Region valid descriptor" "unused,Valid"
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>1.
group.long aux:0x449++2 "Secure MPU region 1."
INDEX AUX:0x448 %Long 1. 1.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>2.
group.long aux:0x449++2 "Secure MPU region 2."
INDEX AUX:0x448 %Long 2. 2.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>3.
group.long aux:0x449++2 "Secure MPU region 3."
INDEX AUX:0x448 %Long 3. 3.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>4.
group.long aux:0x449++2 "Secure MPU region 4."
INDEX AUX:0x448 %Long 4. 4.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>5.
group.long aux:0x449++2 "Secure MPU region 5."
INDEX AUX:0x448 %Long 5. 5.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>6.
group.long aux:0x449++2 "Secure MPU region 6."
INDEX AUX:0x448 %Long 6. 6.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>7.
group.long aux:0x449++2 "Secure MPU region 7."
INDEX AUX:0x448 %Long 7. 7.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>8.
group.long aux:0x449++2 "Secure MPU region 8."
INDEX AUX:0x448 %Long 8. 8.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>9.
group.long aux:0x449++2 "Secure MPU region 9."
INDEX AUX:0x448 %Long 9. 9.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>10.
group.long aux:0x449++2 "Secure MPU region 10."
INDEX AUX:0x448 %Long 10. 10.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>11.
group.long aux:0x449++2 "Secure MPU region 11."
INDEX AUX:0x448 %Long 11. 11.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>12.
group.long aux:0x449++2 "Secure MPU region 12."
INDEX AUX:0x448 %Long 12. 12.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>13.
group.long aux:0x449++2 "Secure MPU region 13."
INDEX AUX:0x448 %Long 13. 13.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>14.
group.long aux:0x449++2 "Secure MPU region 14."
INDEX AUX:0x448 %Long 14. 14.
COPY
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>15.
group.long aux:0x449++2 "Secure MPU region 15."
INDEX AUX:0x448 %Long 15. 15.
COPY
ENDIF
TREE.END
ELSE
// Non-Secure Memory Protection Unit
BASE  AUX:0x422
GROUP.LONG 0++7  "MPU region 0."
line.long 0x00 "MPU_RDB,MPU Region Descriptor Base Registers,"
hexmask.long.long 0x00 05.--31. 32.  "BASE ,Base Address"
bitfld.long       0x00 00.--00.      "   V "    "unused,Valid"
line.long 0x04 "MPU_RDP,MPU Region Descriptor Permissions Registers"
textfld     "Perms   R W X          R W X"
newline
textfld     "General"
bitfld.long 0x04 05. " ,General Read Permission"        "-,R"
bitfld.long 0x04 04. " ,General Write Permission"       "-,W"
bitfld.long 0x04 03. " ,General Execute Permission"     "-,X"
textfld     "   Kernel"
bitfld.long 0x04 08. " ,Kernel-only Read Permission"    "-,R"
bitfld.long 0x04 07. " ,Kernel-only Write Permission"   "-,W"
bitfld.long 0x04 06. " ,Kernel-only Execute Permission" "-,X"
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
newline
bitfld.long 0x04 00.--04. "Size    "  "-,4.,8.,16.,32.,64.,128.,256.,512.,1.KB,2.KB,4.KB,8.KB,16.KB,32.KB,64.KB,128.KB,256.KB,512.KB,1.MB,2.MB,4.MB,8.MB,16.MB,32.MB,64.MB,128.MB,256.MB,512.MB,1.GB,2.GB,4.GB"
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>1.
BASE  AUX:0x424
GROUP.LONG 0++7 "MPU region 1."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>2.
BASE  AUX:0x426
GROUP.LONG 0++7 "MPU region 2."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>3.
BASE  AUX:0x428
GROUP.LONG 0++7 "MPU region 3."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>4.
BASE  AUX:0x42A
GROUP.LONG 0++7 "MPU region 4."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>5.
BASE  AUX:0x42C
GROUP.LONG 0++7 "MPU region 5."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>6.
BASE  AUX:0x42E
GROUP.LONG 0++7 "MPU region 6."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>7.
BASE  AUX:0x430
GROUP.LONG 0++7 "MPU region 7."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>8.
BASE  AUX:0x432
GROUP.LONG 0++7 "MPU region 8."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>9.
BASE  AUX:0x434
GROUP.LONG 0++7 "MPU region 9."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>10.
BASE  AUX:0x436
GROUP.LONG 0++7 "MPU region 10."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>11.
BASE  AUX:0x438
GROUP.LONG 0++7 "MPU region 11."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>12.
BASE  AUX:0x43A
GROUP.LONG 0++7 "MPU region 12."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>13.
BASE  AUX:0x43C
GROUP.LONG 0++7 "MPU region 13."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>14.
BASE  AUX:0x43E
GROUP.LONG 0++7 "MPU region 14."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
SIF ((Data.Long(AUX:0x6D)>>8)&0xff)>15.
BASE  AUX:0x440
GROUP.LONG 0++7 "MPU region 15."
COPY 2
SGROUP
GETX 4 %Long 0
VARX 4 %Long ((PER.B.L(0)>>7)&0x1C)|(PER.B.L(0)&3)
WRITEBACK
VARX 0 %Long ((PER.B.L(4)&0x1C)<<7)|(PER.B.L(4)&3)|(PER.B.L(0)&0xFFFFF1FC)
SETX 4 %Long 0
COPY 2
ENDIF
ENDIF
TREE.END
ENDIF
SIF (coretype()>=900.)&&((data.long(aux:0xCE)&0xff)>0)
CONFIG 32.
WIDTH  22.
TREE "Cache"
// ARC-HS with System Level Cache
rgroup.long aux:0xCE++0
line.long 0x00 "SLC_BUILD,System Level Cache Build Register"
hexmask.long.byte 0x00 00.--07. 1. " VERSION     ,Current Version"
hexmask.long.byte 0x00 08.--15.   "      NUMBER  ,Identity of SLC"
rgroup.long aux:0x901++0
line.long 0x00 "SLC_CONFIG,System Cache Configuration Register"
bitfld.long 0x00 00.--03. " CACHE_SIZE ,Cache size" "128.KiB,256.KiB,512.KiB,1.MiB,2.MiB,4.MiB,8.MiB,..."
bitfld.long 0x00 04.--05. "  LSIZE ,Cache line size" "128.B,64.B,..."
bitfld.long 0x00 06.--07. "  WAYS ,Ways" "4,8,16.,..."
newline
bitfld.long 0x00 08.--10. " DBANK ,Number of data banks" "4.banks,8.banks,16.banks,32.banks,..."
bitfld.long 0x00 11.--14. "    DATA_TIME ,Number of cycles for accessing data bank"
newline
bitfld.long 0x00 15.--17. " TBANK ,Number of tag banks" "4.banks,8.banks,16.banks,32.banks,..."
bitfld.long 0x00 18.--21. "    TAG_TIME  ,Number of cycles for accessing the tag bank"
newline
bitfld.long 0x00 22.--23. " PMS ,Performance monitor counter size" "32-bit,48-bit,64-bit,none"
decmask.long.word 0x00 24.--28. 1 1 "        PM_NUM,Performance counter number"
bitfld.long 0x00 29.      "   BIST ,Built In Self Test" "N/A,enabled"
bitfld.long 0x00 30.--31. "   EP , ECC and parity options" "N/A,Parity,ECC (no correction),ECC with correction"
group.long aux:0x903++0
line.long 0x00 "SLC_CONTROL,System Cache Control Register"
bitfld.long       0x00 00.        " CD ,Cache disable bit" "SLC enabled,SLC disabled"
bitfld.long       0x00 02.        "   SB ,Success bit for last cache operation" "failed,success"
bitfld.long       0x00 08.        "     BS ,Busy status" "idle,aux op."
bitfld.long       0x00 03.--04.   "     LFP ,Line Fill Prefetch option" "disable,instruction only,data only,instruction + data"
newline
bitfld.long       0x00 05.        " AT ,Address debug type for RAM access" "direct,cache ctrl."
bitfld.long       0x00 06.        "    IM ,Invalidation mode (Action on invalidate command)" "invld only,invld+flush"
bitfld.long       0x00 07.        " LM ,Lock mode effect of flush command on lock entry" "lock only,flush+lock"
bitfld.long       0x00 09.--11.   "  RGN_OP ,Region operation" "flush,invalidate,prefetch,..."
newline
bitfld.long       0x00 12.--15.   " ILF ,Number of instruction line fill prefetch" "1 extra line,2 extra lines,..."
bitfld.long       0x00 16.--19.   " DLF ,Number of data line fill prefetches" "1 extra line,2 extra lines,..."
hexmask.long.byte 0x00 20.--27. 1. " STRIDE ,Stride offset"
wgroup.long aux:0x904++0
line.long 0x00 "SLC_CACHE_FLUSH,System Cache Flush Register"
button "Flush cache" "Data.Set AUX:0x904 %LONG 1"
if (data.long(aux:0x903)>>6.&1)>0
wgroup.long aux:0x905++0
line.long 0x00 "SLC_CACHE_IVDC,System Cache Invalidation Register"
button "Invalidate and Flush cache" "Data.Set AUX:0x905 %LONG 1"
else
wgroup.long aux:0x905++0
line.long 0x00 "SLC_CACHE_IVDC,System Cache Invalidation Register"
button "Invalidate cache" "Data.Set AUX:0x905 %LONG 1"
endif
; For the following register pairs the HI register must
; be set first, since LO register triggers the action.
sgroup
WRITEBACK
SETX aux:0x90F %long 4
SETX aux:0x90E %long 0
line.quad 0x00 "SLC_LOCK_LINE,[AUX:0x90E] SLC Lock data cache line"
sgroup
WRITEBACK
SETX aux:0x911 %long 4
SETX aux:0x910 %long 0
line.quad 0x00 "SLC_IVDC_LINE,[AUX:0x910] Invalidate data cache line"
sgroup
WRITEBACK
SETX aux:0x913 %long 4
SETX aux:0x912 %long 0
line.quad 0x00 "SLC_FLUSH_LINE,[AUX:0x912]SLC Flush data cache line"
sgroup
WRITEBACK
SETX aux:0x915 %long 4
SETX aux:0x914 %long 0
line.quad 0x00 "SLC_REGION_START,[AUX:0x914]SLC Region Start"
sgroup
WRITEBACK
SETX aux:0x917 %long 4
SETX aux:0x916 %long 0
line.quad 0x00 "SLC_REGION_END,[AUX:0x916]SLC Region End"
sgroup
WRITEBACK
SETX aux:0x919 %long 4
SETX aux:0x918 %long 0
line.quad 0x00 "SLC_ACCESS_RAM,[AUX:0x918]SLC Access RAM"
wgroup.long aux:0x91A++0
line.long 0x00 "SLC_DIRECT_ACCESS,SLC Direct Access Address Register"
;   bitfld.long       0x00 00.--03.   "  WAY,Selected way" "0,1,2,3,4,5,6,7,8,9,10.,11.,12.,13.,14.,15."
;   hexmask.long.long 0x00 04.--20. 1. "  INDEX,Index to arrays"
;   bitfld.long       0x00 28.        "  DD,Data disable" "read/write data permitted,read/write data disabled"
;   bitfld.long       0x00 29.        "  SD,Status disable" "read/write status register,read/write status register disabled"
group.long aux:0x91B++1
line.quad 0x00 "SLC_TAG,SLC TAG Register"
bitfld.long        0x00 00.      "  V " "0,1"
hexmask.long.byte  0x00 02.--05. "   WAY ,Selected way"
hexmask.long.byte  0x00 07.--14. "   INDEX ,The index to tag banks"
hexmask.quad.hbyte 0x00 15.--63. "   TAG ,Tag address from tag banks"
group.long aux:0x91D++0
line.long 0x00 "SLC_STATUS,SLC Status data"
group.long aux:0x91F++3
line.long 0x00 "SLC_DATA0,SLC DATA, first 32-bit"
line.long 0x04 "SLC_DATA1,SLC DATA, second 32-bit"
line.long 0x08 "SLC_DATA2,SLC DATA, third 32-bit"
line.long 0x0C "SLC_DATA3,SLC DATA, fourth 32-bit"
rgroup.long aux:0x923++1
line.long 0x00 "SLC_FAULT_ADDRESS_LO,SLC Fault register, lower address"
line.long 0x04 "SLC_FAULT_ADDRESS_HI,SLC Fault register, upper address"
group.long aux:0x925++0
line.long 0x00 "SLC_FAULT_STATUS,Fault status register"
group.long aux:0x926++0
line.long 0x00 "SLC_PM_COMMAND,Performance Montior Command Register"
rgroup.long aux:0x927++0
line.long 0x00 "SLC_PM_EVENT_ENABLE,Performance Montior Event Enable Register"
group.long aux:0x928++0
line.long 0x00 "SLC_PM_CNT_OVERFLOW,Performance Montior Counter Overflow"
group.long aux:0x929--0x93A
line.quad 0x00 "SLC_PM_EVENT_CNT0,Performance Montior Event Counter 0"
line.quad 0x08 "SLC_PM_EVENT_CNT1,Performance Montior Event Counter 1"
line.quad 0x10 "SLC_PM_EVENT_CNT2,Performance Montior Event Counter 2"
line.quad 0x18 "SLC_PM_EVENT_CNT3,Performance Montior Event Counter 3"
line.quad 0x20 "SLC_PM_EVENT_CNT4,Performance Montior Event Counter 4"
line.quad 0x28 "SLC_PM_EVENT_CNT5,Performance Montior Event Counter 5"
line.quad 0x30 "SLC_PM_EVENT_CNT6,Performance Montior Event Counter 6"
line.quad 0x38 "SLC_PM_EVENT_CNT7,Performance Montior Event Counter 7"
line.quad 0x40 "SLC_PM_EVENT_CNT8,Performance Montior Event Counter 8"
TREE.END
ENDIF
CONFIG 36.
WIDTH  18.
TREE "Build Configuration Registers"
; Build Register:  Core Configuration
rgroup.long aux:0x04++0
line.long 0x00 "IDENTITY,Processor Identification Register"
hexmask.long.word 0x00 16.--31. 1     "CHIPID      ,Chip Identifier Assigned"
hexmask.long.byte 0x00 08.--15. 1     "          ARCNUM  ,Identity Number"
hexmask.long.byte 0x00 00.--07. 1     "          ARCVER ,Version Number"
sgroup
varx   0 %byte data.long(aux:0x04)&0xff
constx 1 %byte 0
varx   1 %byte PER.B.B(1)+conv.booltoint(PER.B.B(0)>=0x10)+conv.booltoint(PER.B.B(0)>=0x20)
varx   1 %byte PER.B.B(1)+conv.booltoint(PER.B.B(0)>=0x25)+conv.booltoint(PER.B.B(0)>=0x30)
varx   1 %byte PER.B.B(1)+conv.booltoint(PER.B.B(0)>=0x40)+conv.booltoint(PER.B.B(0)>=0x41)
varx   1 %byte PER.B.B(1)+conv.booltoint(PER.B.B(0)>=0x50)+conv.booltoint(PER.B.B(0)>=0x60)
bitfld.byte       0x01 00.--04. " -> " "ARCtangent-A4,ARCtangent-A5,ARC600,ARC601,ARC700,ARC-EM 1.0,ARC-EM 1.1,ARC-HS,?..."
rgroup.long aux:0x60++0
line.long 0x00 "BCR_VER,Build Configuration Registers Version"
hexmask.long.byte 0x00 00.--07.   1   "VERSION     ,Version of Build Configuration Registers"
sif coretype()>=900.
rgroup.long aux:0xCF++0
line.long 0x00 "CLUSTER_BUILD,CLUSTER Build Register"
hexmask.long.byte 0x00 00.--07.   1   "VERSION     ,Version of Build Configuration Registers"
decmask.long.byte 0x00 08.--15.   1   "            CORES ,Number of cores in the coherent cluster"
textfld "."
decmask.long.byte 0x00 16.--23.   1   "         ENTRIES ,maximum number of concurrent read and write transactions supported by the interconnect within the coherent cluster"
textfld "."
bitfld.long       0x00 24.       "      C  ,Coherent I/O channel" "N/A,supported"
endif
; Build Register:  ARC CPU Core
rgroup.long aux:0x68++0 "Core Configuration"
line.long 0x00 "VECBASE_AC_BUILD,Interrupt Vector Base Address ARCompact"
hexmask.long.byte 0x00 02.--09.   1   "VERSION     ,Version of Interrupt Unit"
hexmask.long.long 0x00 10.--31. 0x400 "            ADDR    ,Address of the interrupt vectors"
bitfld.long       0x00 00.--01.       "    E      ,Number of Interrupts in System" "16.Interrupts,32.Interrupts,8 Interrupts,8 Interrupts"
rgroup.long aux:0xc1++0
line.long 0x00 "ISA_CONFIG,Instruction Set Configuration Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Instruction Set Version"
bitfld.long       0x00 08.--10. "            PC_SIZE ,Width of Program Counter register" "16.bits,20.bits,24.bits,28.bits,32.bits,%x..."
bitfld.long       0x00 20. "     Endian ,Byte ordering" "Little,Big"
newline
bitfld.long       0x00 16.--19. "ADDR_SIZE   ,Address bits handled by the processor" "16.bits,20.bits,24.bits,28.bits,32.bits,%x..."
bitfld.long       0x00 12.--14. "       LPC_SIZE,Width of LP_COUNT register"    "N/A,8 bits,12.bits,16.bits,20.bits,24.bits,28.bits,32.bits"
newline
bitfld.long       0x00 24.--27. "CODE_DENS   ,Code density optional instructions" "N/A,version 1,version 2,ISA_PROFILE,%x..."
bitfld.long       0x00 28.--31. "   DIV_REM ,DIV/REM instructions"    "N/A,bit-serial,radix4/fast,%x..."
bitfld.long       0x00 21.      " ATOMIC ,Atomic option: LLOCK and SCOND instructions" "N/A,present"
sif coretype()>=900.
newline
bitfld.long       0x00 22.--22. "DATA_ALIGNED,alignment of memory references" "required,optional"
bitfld.long       0x00 23.--23. "      LL64    ,LL64 option : LDD and STD instructions" "N/A,present"
endif
sif ((data.long(AUX:0xc1)>>24.)&0x0f)==3
rgroup.long aux:0xF8++0
line.long 0x00 "ISA_PROFILE,ARCv2 ISA Profile Register"
hexmask.long.byte 0x00   0.--7. 1 "VERSION     ,Instruction Set Version"
hexmask.long.byte 0x00 24.--27. 1 "            G1 ,Code density 1"
hexmask.long.byte 0x00 24.--27. 1 "     G2 ,Code density 2"
hexmask.long.byte 0x00 24.--27. 1 "     G3 ,Code density 3"
endif
rgroup.long aux:0x6e++0
line.long 0x00 "RF_BUILD,Core Register Set Configuration Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Version of Core Register Set"
bitfld.long       0x00 11.--13. "            Banks      ,Number of Register Banks in addition to the main core register bank" "0,1,2,3,4,5,6,7"
sif ((data.long(AUX:0x6e)>>11.)&3)!=0
bitfld.long       0x00 14.--15. "        Dubl.   ,Number of duplicated registers in each additional register bank" " 4., 8.,16.,32."
endif
newline
bitfld.long 0x00 10. "Reset       ,Reset State" "Not cleared,Cleared"
bitfld.long 0x00 9. "   Entries   ,Number of Entries" "32.,16."
bitfld.long 0x00 8. "       Ports    ,Number of Ports" "3.,4."
rgroup.long aux:0xf3++0
line.long 0x00 "IRQ_BUILD,Interrupt Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Version"
decmask.long.byte 0x00 08.--15. 1 "            IRQS    ,   Number of interrupts available in the Interrupt Controller"
textfld "."
decmask.long.byte 0x00 16.--23. 1 "       EXTS  , Number of available external interrupt lines"
textfld "."
newline
textfld "                          "
bitfld.long       0x00 24.--27. "PRIOS     ,Number of interrupt priority levels" "16.bits,20.bits,24.bits,28.bits,32.bits,..."
bitfld.long       0x00 28.--28. "   FIRQ   ,Fast Interrupt Option (FIRQ_OPTION)"    "N/A,present"
rgroup.long aux:0xfe++0
line.long 0x00 "IFQUEUE_BUILD,Instruction Fetch Queue Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Version of the Instruction Fetch Queue"
bitfld.long       0x00 8.--9. "            Entries ,Instruction Fetch Queue entries (BD)" "1,2,4,8"
rgroup.long aux:0x63++0
line.long 0x00 "BTA_LINK_BUILD,BTA Configuration Build Register"
bitfld.long 0x00 0. "P           ,Presence of BTA Registers" "BTA_Lx absent,BTA_Lx present"
sif coretype()>=900.
rgroup.long aux:0xC0++0
line.long 0x00 "BPU_BUILD,Branch Prediction Unit Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
sif (data.long(aux:0xC0)&0xFF)!=0
bitfld.long 0x00 08.--10. "      BCE ,Number of Branch Cache (BC) entries"  "256.,512.,1.K,2.K,..."
bitfld.long 0x00 11.--13. "     PTE ,Number of Prediction Table (PT) entries" "2.K,8.K,8.K,10.K,..."
bitfld.long 0x00 14.--15. "     RSE ,Number of Return-Stack (RS) Entries" "4,8,..."
newline
bitfld.long 0x00 16.      "FT          ,Tags in Branch Cache" "partial,full"
decmask.long.byte 0x00 17.--21. 1 " TS ,Size of Branch Cache Tag"
textfld "."
bitfld.long 0x00 22.--23. "     TQE ,Number of entries for Top of Stack (TOS) Queue" "0,2,5,8"
bitfld.long 0x00 24.--25. "        FBE ,Number of eight-byte entries in IFU Fetch Buffer" "1,2,..."
endif
endif
rgroup.long aux:0xC8++0
line.long 0x00 "FPU_BUILD,Floating-Point Unit Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
bitfld.long       0x00 08. "      SP  ,Support for single-precision floating-point instructions" "no,yes"
bitfld.long       0x00 09. "      SF  ,Support for single-precision fusedMultiplyAdd and fusedMultiplySubtract instructions" "no,yes"
bitfld.long       0x00 10. "      SC  ,Support for single-precision floating-point format conversion instructions" "no,yes"
bitfld.long       0x00 11. "      SD  ,Support for single-precision square-root and divide instructions" "no,yes"
newline
textfld "                    "
sif coretype()>=900.
bitfld.long       0x00 16. "DP  ,Support for double-precision floating-point instructions" "no,yes"
bitfld.long       0x00 17. "      DF  ,Support for double-precision fusedMultiplyAdd and fusedMultiplySubtract instructions." "no,yes"
bitfld.long       0x00 18. "      DC  ,Support for double-precision floating-point format conversion instructions." "no,yes"
bitfld.long       0x00 19. "      DD  ,Support for double-precision square-root and divide instructions" "no,yes"
else
bitfld.long       0x00 24. "DP  ,Support for double-precision floating-point instructions" "no,yes"
bitfld.long       0x00 12. "      FM  ,Support for fast multiplication instructions" "2.cycle,1.cycle"
bitfld.long       0x00 13. "  FD  ,Support for fast divide and square root instructions" "14.cycle,1.cycle"
endif
; Build Register:  Memory System
rgroup.long aux:0x78++0 "Memory System"
line.long 0x00 "ICCM_BUILD,ICCM Configuration Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
sgroup
GETX aux:0x78 %Long 4
VARX 0 %Byte ((PER.B.L(4)>>8.)&0x0f)+((PER.B.L(4)>>16.)&0x0f)
VARX 1 %Byte ((PER.B.L(4)>>12.)&0x0f)+((PER.B.L(4)>>20.)&0x0f)
bitfld.byte 0x00 0.--7. "        ICCM0_SIZE ,Size of ICCM0 RAM"     "  0,0.5 KiB,  1.KiB,  2.KiB,  4.KiB,  8.KiB, 16.KiB, 32.KiB, 64.KiB,128.KiB,256.KiB,512.KiB,  1.MiB,  2.MiB,  4.MiB,  8.MiB, 16.MiB, 32.MiB, 64.MiB,128.MiB,256.MiB,512MiB,?..."
bitfld.byte 0x01 0.--7. "      ICCM1_SIZE ,Size of ICCM1 RAM"       "  0,0.5 KiB,  1.KiB,  2.KiB,  4.KiB,  8.KiB, 16.KiB, 32.KiB, 64.KiB,128.KiB,256.KiB,512.KiB,  1.MiB,  2.MiB,  4.MiB,  8.MiB, 16.MiB, 32.MiB, 64.MiB,128.MiB,256.MiB,512MiB,?..."
sif coretype()<900.
bitfld.long 0x04 24.--27. "      NVM_SIZE ,Size of non-volatile ICCM" "  0,0.5 KiB,  1.KiB,  2.KiB,  4.KiB,  8.KiB, 16.KiB, 32.KiB, 64.KiB,128.KiB,256.KiB,512.KiB,  1.MiB,  2.MiB,  4.MiB,  8.MiB"
bitfld.long 0x04 28.--28. " NI ,NV_ICCM implementation" "no FIQ,for FIQ"
endif
rgroup.long aux:0x74++0
line.long 0x00 "DCCM_BUILD,DCCM Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
sgroup
GETX AUX:0x74 %Long 4
VARX 0 %Byte ((PER.B.L(4)>>8.)&0x0f)+((PER.B.L(4)>>12.)&0x0f)
bitfld.byte 0x00 0.--7. "         DCCM_SIZE ,Size of DCCM RAM"   "  0,0.5 KiB,  1.KiB,  2.KiB,  4.KiB,  8.KiB, 16.KiB, 32.KiB, 64.KiB,128.KiB,256.KiB,512.KiB,  1.MiB,  2.MiB,  4.MiB,  8.MiB, 16.MiB, 32.MiB, 64.MiB,128.MiB,256.MiB,512MiB,?..."
sif coretype()>=900.
sif (data.long(AUX:0x74)&0xff)>=4.
hexmask.long.byte 0x04 17.--19. 1 "      Cycles ,n-cycle memory"
endif
bitfld.long 0x04 20.--20. "    DPW ,Support of partial writes through DMI interface" "no,yes"
else
bitfld.long 0x04 16.--16. "      IL ,Support interleaving" "no,yes"
endif
rgroup.long aux:0x77++0
line.long 0x00 "I_CACHE_BUILD,Instruction Cache Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
bitfld.long 0x00 12.--15. "            Cap.    ,Cache capacity" "res.,1 KiB,2 KiB,4 KiB,8 KiB,16.KiB,32.KiB,64.KiB,..."
newline
bitfld.long 0x00  8.--11. "Assoc       ,Cache Associativity" "direct,2 way,4 way, 8 way,..."
bitfld.long 0x00 16.--19. "        BSize   ,Block Size" "16.bytes,32.bytes,64.bytes,128.bytes,256.bytes,..."
bitfld.long 0x00 20.--21. "   FtrLev ,Feature Level" "basic,lock & flush,lock & flush Pro,..."
rgroup.long aux:0x72++0
line.long 0x00 "D_CACHE_BUILD,Data Cache Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
bitfld.long 0x00 12.--15. "            Cap.    ,Cache capacity" "res.,1 KiB,2 KiB,4 KiB,8 KiB,16.KiB,32.KiB,64.KiB,..."
newline
bitfld.long 0x00  8.--11. "Assoc       ,Cache Associativity" "direct,2 way,4 way, 8 way,..."
bitfld.long 0x00 16.--19. "        BSize   ,Block Size" "16.bytes,32.bytes,64.bytes,128.bytes,256.bytes,..."
bitfld.long 0x00 20.--21. "   FtrLev ,Feature Level" "basic,lock & flush,lock & flush Pro,..."
sif coretype()>=900.
rgroup.long aux:0xCE++0
line.long 0x00 "SLC_BUILD,System Level Cache Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
hexmask.long.byte 0x00 08.--15.   "            NUMBER  ,Identity of SLC"
endif
sif coretype()>=900.
sif (data.long(AUX:0x6f)&0xFF000000)!=0
rgroup.long aux:0x6A++0
line.long 0x00 "DATA_UNCACHED,Data Uncached Build Register"
hexmask.long.byte 0x00 00.--07.         1 "VERSION     ,Current Version"
hexmask.long.long 0x00 24.--31. 0x1000000 "            ADDR    ,Base Address of the Data Uncached Region"
bitfld.long       0x00 08.--15.           "    SIZE   ,Size of the Data Uncached Region" "16.MiB,32.MiB,64.MiB,128.MiB,256.MiB,512.MiB,1.GiB,2.GiB,?..."
endif
rgroup.long aux:0x6f++0
line.long 0x00 "MMU_BUILD,Memory Management Unit (MMU) Build Register"
hexmask.long.byte 0x00 24.--31. 1 "VERSION     ,Current Version"
sif (Data.Long(AUX:0x6f)>>24.)>=4
// ARC-HS38
bitfld.long       0x00 08.--09.   "            JE      ,Number of normal joint page TLB sets" "1.way/set,2.ways/set,4.ways/set,8.ways/set"
bitfld.long       0x00 10.--11.   "  JA     ,Number of joint TLB ways" "1.way/set,2.ways/set,4.ways/set,8.ways/set"
bitfld.long       0x00 06.--07.   "   JES  ,Number of super joint page TLB entries" "0.entries,16.entries,..."
newline
bitfld.long       0x00 12.        "                          PAE     ,Physical Address Size" "32-bit,40-bit"
bitfld.long       0x00 15.--18.   "      PSZ0   ,normal page size" "res.,1.KiB,2.KiB,4.KiB,8.KiB,16.KiB,32.KiB,64.KiB,128.KiB,256.KiB,512.KiB,1.MiB,2.MiB,4.MiB,8.MiB,16.MiB"
bitfld.long       0x00 19.--22.   "      PSZ1 ,super page size"  "res.,1.KiB,2.KiB,4.KiB,8.KiB,16.KiB,32.KiB,64.KiB,128.KiB,256.KiB,512.KiB,1.MiB,2.MiB,4.MiB,8.MiB,16.MiB"
newline
bitfld.long       0x00 03.--05.   "                          uITLB   ,Number of uITLB entries" "2,4,8,16.,32.,64.,128.,256."
bitfld.long       0x00 00.--02.   "        uDTLB  ,Number of uDTLB entries" "2,4,8,16.,32.,64.,128.,256."
bitfld.long       0x00 23.--23.   "         SL   ,Shared Library ASID" "N/A,present"
elif (Data.Long(AUX:0x6f)>>24.)>=3
// ARC770D
bitfld.long 0x00       20.--23.   "            JA      ,Number of joint NTLB ways" "1 way,2 ways,4 ways,8 ways,16.ways,32.ways,64.ways,128.ways,256.ways,512.ways,1K ways,2K ways,4K ways,8K ways,16K ways,32K ways"
bitfld.long 0x00       16.--19.   "    JE     ,Number of joint TLB entries" "1 entry,2 entries,4 entries,8 entries,16.entries,32.entries,64.entries,128.entries,256.entries,512.entries,1K entries,2K entries,4K entries,8K entries,16K entries,32K entries"
newline
bitfld.long       0x00 08.--11.   " PGSZ        ,Page Size" "res.,1.KiB,2.KiB,4.KiB,8.KiB,16.KiB,..."
hexmask.long.byte 0x00 04.--07. 1 "        ITLB    ,Number of uITLB entries"
hexmask.long.byte 0x00 00.--03. 1 "          DTLB   ,Number of uDTLB entries"
bitfld.long       0x00 15.--15.   "           OSM  ,Overlay Support Mode" "N/A,present"
elif (Data.Long(AUX:0x6f)>>24.)>0
// ARC750D
bitfld.long 0x00       20.--23.   "            JA      ,Number of joint TLB ways" "1 way,2 ways,4 ways,8 ways,16.ways,32.ways,64.ways,128.ways,256.ways,512.ways,1K ways,2K ways,4K ways,8K ways,16K ways,32K ways"
bitfld.long 0x00       16.--19.   "    JE     ,Number of joint TLB entries" "1 entry,2 entries,4 entries,8 entries,16.entries,32.entries,64.entries,128.entries,256.entries,512.entries,1K entries,2K entries,4K entries,8K entries,16K entries,32K entries"
newline
hexmask.long.byte 0x00 08.--15. 1 "ITLB    ,Number of uITLB entries"
hexmask.long.byte 0x00 00.--07. 1 "          DTLB   ,Number of uDTLB entries"
endif
endif
rgroup.long aux:0x6D++0
line.long 0x00 "MPU_BUILD,Memory Protection Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
sif (Data.Long(AUX:0x6D)&0xff)>0
decmask.long.byte 0x00 08.--15. 1 "            Regions,Number of regions supported"
textfld "."
endif
sif (Data.Long(AUX:0x6D)&0xff)>=4
bitfld.long 0x00 16.--16. "        S , Supports secure regions" "-,supported"
bitfld.long 0x00 17.--17. "  I , Supports SID mechanism"        "-,supported"
endif
sif coretype()<900.
rgroup.long aux:0xDB++0
line.long 0x00 "SEC_BUILD,Secure Build Configuration Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
sif (data.long(aux:0xDB)&0xFF)!=0
bitfld.long 0x00 12.--12. "                                S ,normal/secure modes" "-,supported"
newline
bitfld.long 0x00 16.--17.         "I0SM  ,ICCM0 secure configuration"  "all normal,all secure,upper secure,%x..."
bitfld.long 0x00 20.--21.  "        NSM  ,Non-volatile memory secure configuration"  "all normal,%x..."
bitfld.long 0x00 10.--11. "    EI ,Instruction Encryption" "-,supported,%x..."
newline
bitfld.long 0x00 18.--19.        "I1SM  ,ICCM1 secure configuration"   "all normal,all secure,upper secure,%x..."
bitfld.long 0x00 22.--23. "        DSM  ,DCCM secure configuration"    "all normal,all secure,upper secure,%x..."
bitfld.long 0x00 08.--09. "  ED ,Data Encryption" "-,supported,%x..."
endif
endif
rgroup.long aux:0xC9++0
line.long 0x00 "CPROT_BUILD,Code Protection Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
rgroup.long aux:0xC7++0
line.long 0x00 "ECC_BUILD,ECC Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
bitfld.long 0x00  8.--10.   "            ECC     ,protection mode" "no protection,parity protection,ECC protection,..."
rgroup.long aux:0xC5++0
line.long 0x00 "STACK_REGION_BUILD,Stack Region Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
; Build Register:  Debug Features
if (((data.long(aux:0x76)&0xFF)>0)&&((data.long(aux:0x76)&0xFF)<7))
rgroup.long aux:0x76++0 "Debug Features"
line.long 0x00 "AP_BUILD,Actionpoints Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
bitfld.long 0x00 8.--11. "            TYPE    ,Number of Actionpoints" "2 full,4 full,8 full,res.,2 min,4 min,8 min,..."
else
rgroup.long aux:0x76++0 "Debug Features"
line.long 0x00 "AP_BUILD,Actionpoints Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
textfld "            no Actionpoints available"
endif
rgroup.long aux:0xff++0
line.long 0x00 "SMART_BUILD,SmaRT Build Build Register"
hexmask.long.byte 0x00  0.--07. 1 "VERSION     ,Current Version"
decmask.long.word 0x00 10.--31. 1 "            SIZE ,Size of Trace Stack in Records"
textfld ".rec"
rgroup.long aux:0xf2++0
line.long 0x00 "RTT_BUILD,Nexus RTT Interface Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
bitfld.long       0x00 8. "    Prog.Interface ,Has programming interface" "N/A,present"
bitfld.long       0x00 9.--10. "      FtrLev ,Feature level" "small,medium,full,spooky"
hexmask.long.byte 0x00 11.--18. 1 "   PROD_SRC_NUM ,Number assigned to this core by ARC Trace in a multicore configuration"
sif ((data.long(aux:0xf2)&0xFF)>0)
if (data.long(dbg:0x100000)&0x3F)>=5.
rgroup.long dbg:0x100000++0
line.long 0x0 "RTT_BCR,Nexus Real Time Trace Build Register"
hexmask.long.byte 0x00 00.--05. 1 "VERSION     ,Current Version"
decmask.long.byte 0x00 06.--11. 1 "         Producers    ,Number of Producers"
textfld "."
bitfld.long       0x00 22.--23. "     Filters     ,Number of filters" "8.,4.,2.,0."
newline
bitfld.long       0x00 19. "Off-Chip   ,Indicates if Nexus interface is present" " no,yes"
bitfld.long       0x00 18. "          CtrlSize   ,Width of Nexus control signal" "MSEO1,MSEO2"
bitfld.long       0x00 16.--17. "      PortSize ,Width of the Nexus data interface" "MDO4,MDO8,2xMDO8,res."
newline
bitfld.long       0x00 15. "On-Chip    ,Indicates if the on-chip memory support is included" " no,yes"
bitfld.long       0x00 12.--14. "        Int.Memory ,Size of the internal memory" "  4 KiB,  8 KiB, 16.KiB, 32.KiB, 64.KiB,128.KiB,256.KiB,512.KiB"
bitfld.long       0x00 24.--25. "      OCM_W     ,Width of the on-chip memory bus" " 32.bit, 64.bit,128.bit,res."
else
rgroup.long dbg:0x100000++0
line.long 0x0 "RTT_BCR,Nexus Real Time Trace Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
bitfld.long       0x00 08.--11. "         Producers      ,Number of Producers" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
textfld "."
newline
bitfld.long       0x00 19. "Off-Chip   ,Indicates if Nexus interface is present" " no,yes"
bitfld.long       0x00 18. "          CtrlSize   ,Width of Nexus control signal" "MSEO1,MSEO2"
bitfld.long       0x00 16.--17. "      PortSize ,Width of the Nexus data interface" "MDO4,MDO8,MDO16,res."
newline
bitfld.long       0x00 15. "On-Chip    ,Indicates if the on-chip memory support is included" " no,yes"
bitfld.long       0x00 12.--14. "        Int.Memory ,Size of the internal memory" "  4 KiB,  8 KiB, 16.KiB, 32.KiB, 64.KiB,128.KiB,256.KiB,512.KiB"
endif
endif
rgroup.long aux:0xF5++1
line.long 0x00 "PCT_BUILD,Performance Counter Build-Configuration Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
decmask.long.byte 0x00 16.--23. 1 "            Number    ,Number of performance counters"
textfld "."
bitfld.long       0x00 08.--09. "     SIZE       ,Counter size" "32.bit,48.bit,64.bit,res."
decmask.long.byte 0x00 24.--31. 1 "   Min/Max,Number of counters with min/max capability"
textfld "."
line.long 0x04 "CC_BUILD,Countable Conditions Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
decmask.long.word 0x00 16.--31. 1 "            Number  , Number of countable conditions"
textfld "."
; Build Register:  Peripherals
if (data.long(aux:0x69)&0xFFFFFF00)!=0
rgroup.long aux:0x69++0 "Peripherals"
line.long 0x00 "P_BASE_ADDR,Peripheral Base Address Build Register"
hexmask.long.byte 0x00 00.--07.   1 "VERSION     ,Current Version"
hexmask.long.long 0x00 08.--31. 100 "            ADDR    ,Peripheral Base Address"
else
rgroup.long aux:0x69++0 "Peripherals"
line.long 0x00 "P_BASE_ADDR,Peripheral Base Address Build Register"
hexmask.long.byte 0x00 00.--07.   1 "VERSION     ,Current Version"
textfld "            no peripherals available (due to P_BASE_ADDR)"
endif
rgroup.long aux:0x75++0
line.long 0x00 "TIMER_BUILD,Enhanced Timers Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
bitfld.long 0x00 9. "               T1   ,Timer 1 Present" "N/A,present"
bitfld.long 0x00 8. "       T0   ,Timer 0 Present" "N/A,present"
rgroup.long aux:0xD0++0
line.long 0x00 "MCIP_SYSTEM_BUILD,ARConnect Build Register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
decmask.long.word 0x00 16.--21. 1 "            CORENUM , Number of cores connected to ARConnect"
textfld "."
bitfld.long 0x00 13. "       ICD  ,inter-core debug unit"          "N/A,yes"
sif (data.long(aux:0xD0)&0xFF)!=0
newline
bitfld.long 0x00 8.  "      BSU  ,bus slave unit"                 "N/A,yes"
bitfld.long 0x00 9.  "      ICI  ,inter-core interrupt unit"      "N/A,yes"
bitfld.long 0x00 10. "      ICS  ,inter-core semaphore unit"      "N/A,yes"
bitfld.long 0x00 11. "      ICM  ,inter-core message unit"        "N/A,yes"
newline
bitfld.long 0x00 12. "      PMU  ,power management unit"          "N/A,yes"
bitfld.long 0x00 22. "      LLM  ,low latency memory unit"        "N/A,yes"
bitfld.long 0x00 23. "      IDU  ,interrupt distribution unit"    "N/A,yes"
bitfld.long 0x00 14. "      GRTC ,global real-time counter unit"  "N/A,yes"
endif
sif (data.long(aux:0xD0)&0x0f)>0
sif ((data.long(aux:0xD0)>>10.)&1)>0
rgroup.long aux:0xD1++0
line.long 0x00 "MCIP_SEMA_BUILD,Inter-core semaphore unit build register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
bitfld.long 0x00 8.--9. "            NUMSEMAS  , Number of Semaphores" "8.,16.,32.,"
endif
sif ((data.long(aux:0xD0)>>11.)&1)>0
rgroup.long aux:0xD2++0
line.long 0x00 "MCIP_MESSAGE_BUILD,Inter-core message unit build register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
bitfld.long 0x00 8.--10. "            MPSS      , Size of the message-passing SRAM" "128.B,256.B,512.B,1.KiB,2.KiB,4.KiB,8.KiB,16.KiB"
endif
sif ((data.long(aux:0xD0)>>12.)&1)>0
rgroup.long aux:0xD3++0
line.long 0x00 "MCIP_PMU_BUILD,Power management unit build register."
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
bitfld.long 0x00 8.  "            PM        , power-down management functionality" "N/A,present"
bitfld.long 0x00 9.  "       DVGS , Dynamic Voltage and Frequency Scaling" "N/A,present"
endif
sif ((data.long(aux:0xD0)>>22.)&1)>0
rgroup.long aux:0xD4++0
line.long 0x00 "MCIP_LLM_BUILD,Low latency memory unit build register"
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
bitfld.long 0x00 8.--10.  "            CIRQNUM   , Number of common interrupts supported in IDU" "4.,8.,16.,32.,64.,128.,256.,512."
endif
sif ((data.long(aux:0xD0)>>23.)&1)>0
rgroup.long aux:0xD5++0
line.long 0x00 "MCIP_IDU_BUILD,Interrupt distribution unit build register."
hexmask.long.byte 0x00 00.--07. 1 "VERSION     ,Current Version"
bitfld.long 0x00 8.--10.  "            LLMSize   , Size of LLM" "32.KiB,64.KiB,128.KiB,256.KiB,512.KiB,1.MiB,2.MiB,4.MiB"
hexmask.long.byte 0x00 12.--15. 1 "     LLMBase ,Current Version"
bitfld.long 0x00  16.--17.   "   LLMECC ,protection mode" "no protection,parity protection,ECC protection,..."
endif
endif
; Build Register:  Command Extensions
rgroup.long aux:0x7a--0x7f "Command Extensions"
line.long 0x00 "DSP_BUILD,DSP Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
bitfld.long 0x00 8.--8.   "            32x32   ,32x32 operations" "N/A,present"
bitfld.long 0x00 10.--10. " Cmplx.Data ,complex data format operations" "N/A,present"
line.long 0x04 "MULTIPLY_BUILD,Multiply Build Register"
hexmask.long.byte 0x04 0.--7. 1 "VERS.32x32  ,Version of 32x32 Multiply"
sif (data.long(aux:0x7b)&0xff)>2
bitfld.long 0x04 8.--9. "            TYPE    ,Type of Multiply" "serial,parallel,parallel & DSP,res."
endif
bitfld.long 0x04 10.--11. " CYC ,Number of Cycles" "1,2,3,4"
sif ((data.long(aux:0x7b)&0xff)>2)&&((data.long(aux:0x7b)&0x300)>=2)
bitfld.long 0x04 12.--15. " MPY_OPTION ,DSP capabilities" "N/A,7,8,9,..."
endif
newline
hexmask.long.byte 0x04 16.--23. 1 "VERS.16x16  ,Version of 16x16 Multiply"
line.long 0x08 "SWAP_BUILD,Swap Build Register"
hexmask.long.byte 0x08 0.--7. 1 "VERSION     ,Current Version"
line.long 0x0c "NORM_BUILD,Normalize Build Register"
hexmask.long.byte 0x0c 0.--7. 1 "VERSION     ,Current Version"
line.long 0x10 "MINMAX_BUILD,Min/Max Build Register"
hexmask.long.byte 0x10 0.--7. 1 "VERSION     ,Current Version"
line.long 0x14 "BARREL_BUILD,Barrel Shifter Build Register"
hexmask.long.byte 0x14 0.--7. 1 "VERSION     ,Current Version"
bitfld.long 0x00 8.--9. "    SHIFT_OPTION    ,Shift Option" "Single-bit shifts only,Single-bit and shift-assist instructions,Single-bit and barrel-shift instructions,All shift instructions"
rgroup.long aux:0x62++0
line.long 0x00 "CRC_BUILD,CRC Extension Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current Version"
rgroup.long aux:0x64++0
line.long 0x00 "VBFDW_BUILD,Dual Viterbi Butterfly Instruction Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Current version"
rgroup.long aux:0x65++0
line.long 0x00 "TEL_INSTR_BUILD,Extended Arithmetic Configuration Build Register"
hexmask.long.byte 0x00 0.--7. 1 "VERSION     ,Version of Extended Arithmetic"
TREE.END
TEXTLINE ""


AUTOINDENT.ON LEFT TREE

TREE "CLKGEN MODULE"
    BASE ad:0xb20000
    GROUP.LONG 0x000++0x4
        LINE.LONG 0x00 "CLKGEN_READY_50M,Ready indicator for Crystal Clock "
            BITFLD.LONG 0x00 0. "READY_50M    ,READY_50M" "0,1"
    GROUP.LONG 0x004++0x4
        LINE.LONG 0x00 "CLKGEN_READY_PLL,Ready indicator for PLL clock "
            BITFLD.LONG 0x00 0. "READY_PLL    ,READY_PLL" "0,1"
    GROUP.LONG 0x008++0x4
        LINE.LONG 0x00 "CLKGEN_SEL_300M,Source selector for CPU "
            BITFLD.LONG 0x00 0. "SEL_300M    ,SEL_300M" "0,1"
    GROUP.LONG 0x00C++0x4
        LINE.LONG 0x00 "CLKGEN_SEL_400M,Source selector for other modules "
            BITFLD.LONG 0x00 0. "SEL_400M    ,SEL_400M" "0,1"
    GROUP.LONG 0x010++0x4
        LINE.LONG 0x00 "CLKGEN_SEL_CAN0,Clock selector for CAN0 "
            BITFLD.LONG 0x00 0. "SEL_CAN0    ,SEL_CAN0" "0,1"
    GROUP.LONG 0x014++0x4
        LINE.LONG 0x00 "CLKGEN_SEL_CAN1,Clock selector for CAN1 "
            BITFLD.LONG 0x00 0. "SEL_CAN1    ,SEL_CAN1" "0,1"
    GROUP.LONG 0x018++0x4
        LINE.LONG 0x00 "CLKGEN_FSCM_BYPASS,Bypass fscm_o"
            BITFLD.LONG 0x00 0. "FSCM_BYPASS    ,FSCM_BYPASS" "0,1"
    GROUP.LONG 0x01C++0xe4
        LINE.LONG 0x00 "CLKGEN_CRYSTAL_MODE,External crystal"
            BITFLD.LONG 0x00 0. "CRYSTAL_MODE    ,CRYSTAL_MODE" "0,1"
    GROUP.LONG 0x100++0x4
        LINE.LONG 0x00 "CLKGEN_DIV_CPU,Clock divisor for CPU clock "
            BITFLD.LONG 0x00 0.--3. "DIV_CPU    ,DIV_CPU"
    GROUP.LONG 0x104++0x4
        LINE.LONG 0x00 "CLKGEN_DIV_MEM,Clock divisor for Memory "
            BITFLD.LONG 0x00 0.--3. "DIV_MEM    ,DIV_MEM"
    GROUP.LONG 0x108++0x4
        LINE.LONG 0x00 "CLKGEN_DIV_AHB,Clock divisor for AHB bus "
            BITFLD.LONG 0x00 0.--3. "DIV_AHB    ,DIV_AHB"
    GROUP.LONG 0x10C++0x4
        LINE.LONG 0x00 "CLKGEN_DIV_APB,Clock divisor for APB bus "
            BITFLD.LONG 0x00 0.--3. "DIV_APB    ,DIV_APB"
    GROUP.LONG 0x110++0x4
        LINE.LONG 0x00 "CLKGEN_DIV_APB_REF,Clock divisor for APB REF "
            BITFLD.LONG 0x00 0.--3. "DIV_APB_REF    ,DIV_APB_REF"
    GROUP.LONG 0x114++0x4
        LINE.LONG 0x00 "CLKGEN_DIV_CAN_0,Clock divisor for CAN 0 clock "
            BITFLD.LONG 0x00 0.--3. "DIV_CAN_0    ,DIV_CAN_0"
    GROUP.LONG 0x118++0x4
        LINE.LONG 0x00 "CLKGEN_DIV_CAN_1,Clock divisor for CAN 1 clock "
            BITFLD.LONG 0x00 0.--3. "DIV_CAN_1    ,DIV_CAN_1"
    GROUP.LONG 0x11C++0x4
        LINE.LONG 0x00 "CLKGEN_DIV_RF_TEST,Clock divisor for RF test clock "
            BITFLD.LONG 0x00 0.--3. "DIV_RF_TEST    ,DIV_RF_TEST"
    GROUP.LONG 0x120++0xe0
        LINE.LONG 0x00 "CLKGEN_DIV_DIG_TEST,Clock divisor for digital test clock "
            BITFLD.LONG 0x00 0.--3. "DIV_DIG_TEST    ,DIV_DIG_TEST"
    GROUP.LONG 0x200++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_DMA,Clock enabe for DMA"
            BITFLD.LONG 0x00 0. "ENA_DMA    ,ENA_DMA" "0,1"
    GROUP.LONG 0x204++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_ROM_CTRL,Clock enabe for ROM"
            BITFLD.LONG 0x00 0. "ENA_ROM_CTRL    ,ENA_ROM_CTRL" "0,1"
    GROUP.LONG 0x208++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_RAM_CTRL,Clock enabe for RAM"
            BITFLD.LONG 0x00 0. "ENA_RAM_CTRL    ,ENA_RAM_CTRL" "0,1"
    GROUP.LONG 0x20C++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_BB_TOP,Clock enabe for Baseband Top"
            BITFLD.LONG 0x00 0. "ENA_BB_TOP    ,ENA_BB_TOP" "0,1"
    GROUP.LONG 0x210++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_BB_CORE,Clock enabe for Baseband Core"
            BITFLD.LONG 0x00 0. "ENA_BB_CORE    ,ENA_BB_CORE" "0,1"
    GROUP.LONG 0x214++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_FLASH_CTRL,Clock enabe for XIP"
            BITFLD.LONG 0x00 0. "ENA_FLASH_CTRL    ,ENA_FLASH_CTRL" "0,1"
    GROUP.LONG 0x218++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_CRC,Clock enabe for CRC"
            BITFLD.LONG 0x00 0. "ENA_CRC    ,ENA_CRC" "0,1"
    GROUP.LONG 0x21C++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_DMU,Clock enabe for DMU"
            BITFLD.LONG 0x00 0. "ENA_DMU    ,ENA_DMU" "0,1"
    GROUP.LONG 0x220++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_UART_0,Clock enable for UART 0 "
            BITFLD.LONG 0x00 0. "ENA_UART_0    ,ENA_UART_0" "0,1"
    GROUP.LONG 0x224++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_UART_1,Clock enable for UART 1 "
            BITFLD.LONG 0x00 0. "ENA_UART_1    ,ENA_UART_1" "0,1"
    GROUP.LONG 0x228++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_I2C,Clock enable for I2C "
            BITFLD.LONG 0x00 0. "ENA_I2C    ,ENA_I2C" "0,1"
    GROUP.LONG 0x22C++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_SPI_M0,Clock enable for SPI_M0 "
            BITFLD.LONG 0x00 0. "ENA_SPI_M0    ,ENA_SPI_M0" "0,1"
    GROUP.LONG 0x230++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_SPI_M1,Clock enable for SPI_M1 "
            BITFLD.LONG 0x00 0. "ENA_SPI_M1    ,ENA_SPI_M1" "0,1"
    GROUP.LONG 0x234++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_SPI_S,Clock enable for SPI_S "
            BITFLD.LONG 0x00 0. "ENA_SPI_S    ,ENA_SPI_S" "0,1"
    GROUP.LONG 0x238++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_QSPI,Clock enable for QSPI "
            BITFLD.LONG 0x00 0. "ENA_QSPI    ,ENA_QSPI" "0,1"
    GROUP.LONG 0x23C++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_GPIO,Clock enable for GPIO "
            BITFLD.LONG 0x00 0. "ENA_GPIO    ,ENA_GPIO" "0,1"
    GROUP.LONG 0x240++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_TIMER,Clock enabe for TIMER"
            BITFLD.LONG 0x00 0. "ENA_TIMER    ,ENA_TIMER" "0,1"
    GROUP.LONG 0x244++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_PWM,Clock enabe for PWM"
            BITFLD.LONG 0x00 0. "ENA_PWM    ,ENA_PWM" "0,1"
    GROUP.LONG 0x248++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_CAN_0,Clock enable for CAN_0 "
            BITFLD.LONG 0x00 0. "ENA_CAN_0    ,ENA_CAN_0" "0,1"
    GROUP.LONG 0x24C++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_CAN_1,Clock enable for CAN_1 "
            BITFLD.LONG 0x00 0. "ENA_CAN_1    ,ENA_CAN_1" "0,1"
    GROUP.LONG 0x250++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_LVDS,Clock enabe for LVDS"
            BITFLD.LONG 0x00 0. "ENA_LVDS    ,ENA_LVDS" "0,1"
    GROUP.LONG 0x254++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_DBGBUS,Clock enable for debug bus "
            BITFLD.LONG 0x00 0. "ENA_DBGBUS    ,ENA_DBGBUS" "0,1"
    GROUP.LONG 0x258++0x4
        LINE.LONG 0x00 "CLKGEN_ENA_RF_TEST,Clock enabe for RF test"
            BITFLD.LONG 0x00 0. "ENA_RF_TEST    ,ENA_RF_TEST" "0,1"
    GROUP.LONG 0x25C++0xa4
        LINE.LONG 0x00 "CLKGEN_ENA_DIG_TEST,Clock enabe for digital test"
            BITFLD.LONG 0x00 0. "ENA_DIG_TEST    ,ENA_DIG_TEST" "0,1"
    GROUP.LONG 0x300++0x4
        LINE.LONG 0x00 "CLKGEN_SW_REBOOT,software reboot"
            BITFLD.LONG 0x00 0. "SW_REBOOT    ,SW_REBOOT" "0,1"
    GROUP.LONG 0x304++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_DMA,software reset for DMA"
            BITFLD.LONG 0x00 0. "RSTN_DMA    ,RSTN_DMA" "0,1"
    GROUP.LONG 0x308++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_BB_TOP,software reset for Baseband Top"
            BITFLD.LONG 0x00 0. "RSTN_BB_TOP    ,RSTN_BB_TOP" "0,1"
    GROUP.LONG 0x30C++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_BB_CORE,software reset for Baseband Core"
            BITFLD.LONG 0x00 0. "RSTN_BB_CORE    ,RSTN_BB_CORE" "0,1"
    GROUP.LONG 0x310++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_FLASH_CTRL,software reset for flash controller "
            BITFLD.LONG 0x00 0. "RSTN_FLASH_CTRL    ,RSTN_FLASH_CTRL" "0,1"
    GROUP.LONG 0x314++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_CRC,software reset for CRC"
            BITFLD.LONG 0x00 0. "RSTN_CRC    ,RSTN_CRC" "0,1"
    GROUP.LONG 0x318++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_DMU,software reset for for DMU"
            BITFLD.LONG 0x00 0. "RSTN_DMU    ,RSTN_DMU" "0,1"
    GROUP.LONG 0x31C++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_UART_0,software reset for UART 0 "
            BITFLD.LONG 0x00 0. "RSTN_UART_0    ,RSTN_UART_0" "0,1"
    GROUP.LONG 0x320++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_UART_1,software reset for UART 1 "
            BITFLD.LONG 0x00 0. "RSTN_UART_1    ,RSTN_UART_1" "0,1"
    GROUP.LONG 0x324++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_I2C,software reset for I2C "
            BITFLD.LONG 0x00 0. "RSTN_I2C    ,RSTN_I2C" "0,1"
    GROUP.LONG 0x328++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_SPI_M0,software reset for SPI_M0 "
            BITFLD.LONG 0x00 0. "RSTN_SPI_M0    ,RSTN_SPI_M0" "0,1"
    GROUP.LONG 0x32C++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_SPI_M1,software reset for SPI_M1 "
            BITFLD.LONG 0x00 0. "RSTN_SPI_M1    ,RSTN_SPI_M1" "0,1"
    GROUP.LONG 0x330++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_SPI_S,software reset for SPI_S "
            BITFLD.LONG 0x00 0. "RSTN_SPI_S    ,RSTN_SPI_S" "0,1"
    GROUP.LONG 0x334++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_QSPI,software reset for QSPI "
            BITFLD.LONG 0x00 0. "RSTN_QSPI    ,RSTN_QSPI" "0,1"
    GROUP.LONG 0x338++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_GPIO,software reset for GPIO "
            BITFLD.LONG 0x00 0. "RSTN_GPIO    ,RSTN_GPIO" "0,1"
    GROUP.LONG 0x33C++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_TIMER,software reset for TIMER"
            BITFLD.LONG 0x00 0. "RSTN_TIMER    ,RSTN_TIMER" "0,1"
    GROUP.LONG 0x340++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_PWM,software reset for PWM"
            BITFLD.LONG 0x00 0. "RSTN_PWM    ,RSTN_PWM" "0,1"
    GROUP.LONG 0x344++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_CAN_0,software reset for CAN 0 "
            BITFLD.LONG 0x00 0. "RSTN_CAN_0    ,RSTN_CAN_0" "0,1"
    GROUP.LONG 0x348++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_CAN_1,software reset for CAN 1 "
            BITFLD.LONG 0x00 0. "RSTN_CAN_1    ,RSTN_CAN_1" "0,1"
    GROUP.LONG 0x34C++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_LVDS,software reset for LVDS"
            BITFLD.LONG 0x00 0. "RSTN_LVDS    ,RSTN_LVDS" "0,1"
    GROUP.LONG 0x350++0x4
        LINE.LONG 0x00 "CLKGEN_RSTN_RF_TEST,software reset for RF test"
            BITFLD.LONG 0x00 0. "RSTN_RF_TEST    ,RSTN_RF_TEST" "0,1"
    GROUP.LONG 0x354++0x03
        LINE.LONG 0x00 "CLKGEN_RSTN_DIG_TEST,software reset for digital test"
            BITFLD.LONG 0x00 0. "RSTN_DIG_TEST    ,RSTN_DIG_TEST" "0,1"
TREE.END

TREE "CRC MODULE"
    BASE ad:0xC10000
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "CRC_MODE, Mode Control"
            BITFLD.LONG 0x00 0.--2. "CRC_POLY    ,CRC_POLY"
            BITFLD.LONG 0x00 8.--9. "CRC_MODE    ,CRC_MODE" "0,1,2,3"
            BITFLD.LONG 0x00 10.--31. "NULL    ,NULL"
    GROUP.LONG 0x4++0x4
        LINE.LONG 0x00 "CRC_COUNT,CRC Count"
            BITFLD.LONG 0x00 0.--15. "CRC_COUNT    ,CRC_COUNT"
            BITFLD.LONG 0x00 16.--31. "NULL    ,NULL"
    GROUP.LONG 0x8++0x4
        LINE.LONG 0x00 "CRC_RAW,Raw Data"
            HEXMASK.LONG 0x00 0.--31. "CRC_RAW    ,CRC_RAW"
    GROUP.LONG 0xc++0x4
        LINE.LONG 0x00 "CRC_INIT,CRC Initial Value"
            HEXMASK.LONG 0x00 0.--31. "CRC_INIT    ,CRC_INIT"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "CRC_PRE,CRC Preset Value"
            BITFLD.LONG 0x00 0.--31. "CRC_PRE    ,CRC_PRE"
    GROUP.LONG 0x14++0x4
        LINE.LONG 0x00 "CRC_INTR_EN,CRC Interrupt Enable"
            BITFLD.LONG 0x00 0.--2. "CRC_INTR_EN    ,CRC_INTR_EN"
            BITFLD.LONG 0x00 3.--31. "NULL    ,NULL"
    GROUP.LONG 0x18++0x4
        LINE.LONG 0x00 "CRC_INTR_CLR,CRC Interrupt Clear"
            BITFLD.LONG 0x00 0.--2. "CRC_INTR_CLR    ,CRC_INTR_CLR"
            BITFLD.LONG 0x00 3.--31. "NULL    ,NULL"
    GROUP.LONG 0x1c++0x4
        LINE.LONG 0x00 "CRC_INTR_STA,CRC Interrupt Status"
            BITFLD.LONG 0x00 0.--2. "CRC_INTR_STA    ,CRC_INTR_STA"
            BITFLD.LONG 0x00 3.--31. "NULL    ,NULL"
    GROUP.LONG 0x20++0x03
        LINE.LONG 0x00 "CRC_SEC,CRC Sector Value"
            HEXMASK.LONG 0x00 0.--31. "CRC_SEC    ,CRC_SEC"
TREE.END

TREE "LVDS MODULE"
    BASE ad:0xD10000
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "LENR,This register enables and disables apb_lvds configuration."
            BITFLD.LONG 0x00 0. "APB_LVDS ENABLE    ,APB_LVDS ENABLE" "0,1"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "BB_DAT_MUX,This register selects  data source from BaseBand."
            BITFLD.LONG 0x00 0.--2. "BB_DAT_MUX    ,BB_DAT_MUX"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "DUMP_MUX,This register selects the data from BB or DMA to LVDS controller."
            BITFLD.LONG 0x00 0.--2. "DUMP_MUX    ,DUMP_MUX"
    GROUP.LONG 0x0c++0x4
        LINE.LONG 0x00 "OUTPUT_MUX,This register selects the output data on pad from filter or apb_lvds."
            BITFLD.LONG 0x00 0. "OUTPUT_MUX    ,OUTPUT_MUX" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "LVDS_EN,This register enables and disables LVDS controller."
            BITFLD.LONG 0x00 0. "LVDS_EN    ,LVDS_EN" "0,1"
    GROUP.LONG 0x14++0x4
        LINE.LONG 0x00 "LVDS_FRAME,This register selects the polarity of LVDS controller lvds_frame."
            BITFLD.LONG 0x00 0. "LVDS_FRAME    ,LVDS_FRAME" "0,1"
    GROUP.LONG 0x18++0x4
        LINE.LONG 0x00 "LVDS_BIT_ORDER,This register sets LVDS controller lvds_bit_order."
            BITFLD.LONG 0x00 0. "LVDS_BIT_ORDER    ,LVDS_BIT_ORDER" "0,1"
    GROUP.LONG 0x1c++0x4
        LINE.LONG 0x00 "DMACR,This register is DMA controller register."
            BITFLD.LONG 0x00 0. "TDMAE    ,TDMAE" "0,1"
    GROUP.LONG 0x20++0x4
        LINE.LONG 0x00 "DMATDLR,This register is DMA Transmit Data Level control register."
            BITFLD.LONG 0x00 0.--4. "DMATDL    ,DMATDL"
    GROUP.LONG 0x24++0x4
        LINE.LONG 0x00 "TXFLR,This register indicates the  data number in the transmit FIFO memory."
            BITFLD.LONG 0x00 0.--4. "TF    ,TF"
    GROUP.LONG 0x28++0x4
        LINE.LONG 0x00 "TXFTLR,This register controls the threshold value for the transmit FIFO memory."
            BITFLD.LONG 0x00 0.--4. "TFT    ,TFT"
    GROUP.LONG 0x2c++0x4
        LINE.LONG 0x00 "SR,This is a read-only register used to indicate the transmit FIFO status."
            BITFLD.LONG 0x00 1. "TFE    ,TFE" "0,1"
            BITFLD.LONG 0x00 0. "TFNF    ,TFNF" "0,1"
    GROUP.LONG 0x30++0x4
        LINE.LONG 0x00 "VIDR,This register is APB_LVDS Verison ID  register."
            BITFLD.LONG 0x00 0.--31. "IDCODE    ,IDCODE"
    GROUP.LONG 0x34++0x4
        LINE.LONG 0x00 "IMR,This register is interrupt mask register."
            BITFLD.LONG 0x00 0. "TXOIM    ,TXOIM" "0,1"
    GROUP.LONG 0x38++0x4
        LINE.LONG 0x00 "ISR,This register is interrupt status register."
            BITFLD.LONG 0x00 0. "TXOIS    ,TXOIS" "0,1"
    GROUP.LONG 0x3c++0x4
        LINE.LONG 0x00 "RISR,This regsiter is Raw Interrupt Status Register."
            BITFLD.LONG 0x00 0. "RISR    ,RISR" "0,1"
    GROUP.LONG 0x40++0x20
        LINE.LONG 0x00 "TXOICR,This register is Transmit FIFO Overflow Interrupt Clear Register Register."
            BITFLD.LONG 0x00 0. "TXOICR    ,TXOICR" "0,1"
    GROUP.LONG 0x60++0x03
        LINE.LONG 0x00 "DRx,This register is data receive register."
            BITFLD.LONG 0x00 0.--31. "DR    ,DR"
TREE.END

TREE "Timers MODULE"
TREE "TIMER MODULE CHANNEL 1"
    BASE ad:0xb10000
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "TimerNLoadCount (for N = 1 to 4),Value to be loaded into Timer N"
            HEXMASK.LONG 0x00 0.--31. "TimerNLoadCount    ,TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "TimerNCurrentValue (for N = 1 to 4),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "TimerNCurrentValue    ,TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "TimerNControlReg (for N = 1 to 4),Control Register for Timer N. This register controls enabling, operating mode (freerunning or defined-count), and interrupt mask of Timer N. You can program each Timer1ControlReg to enable or disable a specific timer and to control its mode of operation."
            BITFLD.LONG 0x00 3.--31. "RSVD_TimerNControlReg    ,RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 2. "TIMER_INTERRUPT_MASK    ,TIMER_INTERRUPT_MASK" "0,1"
            BITFLD.LONG 0x00 1. "TIMER_MODE    ,TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "TIMER_ENABLE    ,TIMER_ENABLE" "0,1"
            NEWLINE
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "TimerNEOI (for N = 1 to 4),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "RSVD_TimerNEOI    ,RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "TimerNEOI    ,TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "TimerNIntStatus (for N = 1 to 4),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "RSVD_TimerNIntStatus    ,RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "TimerNIntStatus    ,TimerNIntStatus" "0,1"
TREE.END

TREE "TIMER MODULE CHANNEL 2"
    BASE ad:0xb10014
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "TimerNLoadCount (for N = 1 to 4),Value to be loaded into Timer N"
            HEXMASK.LONG 0x00 0.--31. "TimerNLoadCount    ,TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "TimerNCurrentValue (for N = 1 to 4),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "TimerNCurrentValue    ,TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "TimerNControlReg (for N = 1 to 4),Control Register for Timer N. This register controls enabling, operating mode (freerunning or defined-count), and interrupt mask of Timer N. You can program each Timer1ControlReg to enable or disable a specific timer and to control its mode of operation."
            BITFLD.LONG 0x00 3.--31. "RSVD_TimerNControlReg    ,RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 2. "TIMER_INTERRUPT_MASK    ,TIMER_INTERRUPT_MASK" "0,1"
            BITFLD.LONG 0x00 1. "TIMER_MODE    ,TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "TIMER_ENABLE    ,TIMER_ENABLE" "0,1"
            NEWLINE
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "TimerNEOI (for N = 1 to 4),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "RSVD_TimerNEOI    ,RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "TimerNEOI    ,TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "TimerNIntStatus (for N = 1 to 4),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "RSVD_TimerNIntStatus    ,RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "TimerNIntStatus    ,TimerNIntStatus" "0,1"
TREE.END

TREE "TIMER MODULE CHANNEL 3"
    BASE ad:0xb10028
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "TimerNLoadCount (for N = 1 to 4),Value to be loaded into Timer N"
            HEXMASK.LONG 0x00 0.--31. "TimerNLoadCount    ,TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "TimerNCurrentValue (for N = 1 to 4),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "TimerNCurrentValue    ,TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "TimerNControlReg (for N = 1 to 4),Control Register for Timer N. This register controls enabling, operating mode (freerunning or defined-count), and interrupt mask of Timer N. You can program each Timer1ControlReg to enable or disable a specific timer and to control its mode of operation."
            BITFLD.LONG 0x00 3.--31. "RSVD_TimerNControlReg    ,RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 2. "TIMER_INTERRUPT_MASK    ,TIMER_INTERRUPT_MASK" "0,1"
            BITFLD.LONG 0x00 1. "TIMER_MODE    ,TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "TIMER_ENABLE    ,TIMER_ENABLE" "0,1"
            NEWLINE
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "TimerNEOI (for N = 1 to 4),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "RSVD_TimerNEOI    ,RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "TimerNEOI    ,TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "TimerNIntStatus (for N = 1 to 4),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "RSVD_TimerNIntStatus    ,RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "TimerNIntStatus    ,TimerNIntStatus" "0,1"
TREE.END

TREE "TIMER MODULE CHANNEL 4"
    BASE ad:0xb1003C
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "TimerNLoadCount (for N = 1 to 4),Value to be loaded into Timer N"
            HEXMASK.LONG 0x00 0.--31. "TimerNLoadCount    ,TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "TimerNCurrentValue (for N = 1 to 4),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "TimerNCurrentValue    ,TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "TimerNControlReg (for N = 1 to 4),Control Register for Timer N. This register controls enabling, operating mode (freerunning or defined-count), and interrupt mask of Timer N. You can program each Timer1ControlReg to enable or disable a specific timer and to control its mode of operation."
            BITFLD.LONG 0x00 3.--31. "RSVD_TimerNControlReg    ,RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 2. "TIMER_INTERRUPT_MASK    ,TIMER_INTERRUPT_MASK" "0,1"
            BITFLD.LONG 0x00 1. "TIMER_MODE    ,TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "TIMER_ENABLE    ,TIMER_ENABLE" "0,1"
            NEWLINE
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "TimerNEOI (for N = 1 to 4),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "RSVD_TimerNEOI    ,RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "TimerNEOI    ,TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "TimerNIntStatus (for N = 1 to 4),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "RSVD_TimerNIntStatus    ,RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "TimerNIntStatus    ,TimerNIntStatus" "0,1"
TREE.END


TREE "TIMER MODULE OTHERS"
	BASE ad:0xb10000
    GROUP.LONG 0xa0++0x4
        LINE.LONG 0x00 "TimersIntStatus,Contains the interrupt status of all timers in the component."
            BITFLD.LONG 0x00 4.--31. "RSVD_TimersIntStatus    ,RSVD_TimersIntStatus"
            BITFLD.LONG 0x00 0.--3. "TimersIntStatus    ,TimersIntStatus"
    GROUP.LONG 0xa4++0x4
        LINE.LONG 0x00 "TimersEOI,Returns all zeroes (0) and clears all active interrupts."
            BITFLD.LONG 0x00 4.--31. "TimersEOI 31to4 Reserved field    ,TimersEOI 31to4 Reserved field"
            BITFLD.LONG 0x00 0.--3. "TIMERSEOI    ,TIMERSEOI"
    GROUP.LONG 0xa8++0x4
        LINE.LONG 0x00 "TimersRawIntStatus,Contains the unmasked interrupt status of all timers in the component."
            BITFLD.LONG 0x00 4.--31. "RSVD_TIMERSRAWINTSTAT    ,RSVD_TIMERSRAWINTSTAT"
            BITFLD.LONG 0x00 0.--3. "TIMERSRAWINTSTAT    ,TIMERSRAWINTSTAT"
    GROUP.LONG 0xac++0x03
        LINE.LONG 0x00 "TIMERS_COMP_VERSION,Current revision number of the DW_apb_timers component."
            HEXMASK.LONG 0x00 0.--31. "TIMERSCOMPVERSION    ,TIMERSCOMPVERSION"
TREE.END

TREE.END			

TREE "CAN MODULE"
TREE "CAN0 Registers"
    BASE ad:0xbb0000
    GROUP.LONG 0x0000++0x4
        LINE.LONG 0x00 "CRR, Core Release Register"
            BITFLD.LONG 0x00 0.--31. "VER    ,VER"
    GROUP.LONG 0x0004++0x4
        LINE.LONG 0x00 "MCR,Mode Control Register"
            BITFLD.LONG 0x00 18. "TDENA    ,TDENA" "0,1"
            BITFLD.LONG 0x00 17. "RDENA    ,RDENA" "0,1"
            BITFLD.LONG 0x00 16. "ECCENA    ,ECCENA" "0,1"
            BITFLD.LONG 0x00 11.--15. "MCR_RSVD    ,MCR_RSVD"
            NEWLINE
            BITFLD.LONG 0x00 10. "TESTRX    ,TESTRX" "0,1"
            BITFLD.LONG 0x00 8.--9. "TESTTX    ,TESTTX" "0,1,2,3"
            BITFLD.LONG 0x00 7. "TEST    ,TEST" "0,1"
            BITFLD.LONG 0x00 6. "SLEEP    ,SLEEP" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "SPACK    ,SPACK" "0,1"
            BITFLD.LONG 0x00 4. "ROPT    ,ROPT" "0,1"
            BITFLD.LONG 0x00 3. "MON    ,MON" "0,1"
            BITFLD.LONG 0x00 2. "LBACK    ,LBACK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "CFG    ,CFG" "0,1"
            BITFLD.LONG 0x00 0. "RESET    ,RESET" "0,1"
    GROUP.LONG 0x0008++0x4
        LINE.LONG 0x00 "PCR,Protocol Control Register"
            BITFLD.LONG 0x00 31. "FDD    ,FDD" "0,1"
            BITFLD.LONG 0x00 4.--30. "PCR_RSVD    ,PCR_RSVD"
            BITFLD.LONG 0x00 3. "FDO    ,FDO" "0,1"
            BITFLD.LONG 0x00 2. "BRS    ,BRS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TDC    ,TDC" "0,1"
            BITFLD.LONG 0x00 0. "ART    ,ART" "0,1"
    GROUP.LONG 0x000C++0x4
        LINE.LONG 0x00 "TSCCR,Timestamp Counter Configuration Register"
            BITFLD.LONG 0x00 16.--19. "TSCP    ,TSCP"
            BITFLD.LONG 0x00 2.--15. "TSCCR_RSVD    ,TSCCR_RSVD"
            BITFLD.LONG 0x00 0.--1. "TSCM    ,TSCM" "0,1,2,3"
    GROUP.LONG 0x0010++0x4
        LINE.LONG 0x00 "TSCVR,Timestamp Counter Value Register"
            BITFLD.LONG 0x00 0.--15. "TSC    ,TSC"
    GROUP.LONG 0x0014++0x4
        LINE.LONG 0x00 "DBTCR,Data Bit Time Control Register"
            BITFLD.LONG 0x00 24.--27. "DSJW    ,DSJW"
            BITFLD.LONG 0x00 21.--23. "DBTCR_RSVD    ,DBTCR_RSVD"
            BITFLD.LONG 0x00 16.--20. "DBRP    ,DBRP"
            BITFLD.LONG 0x00 13.--15. "DBTCR_RSVD    ,DBTCR_RSVD"
            NEWLINE
            BITFLD.LONG 0x00 8.--12. "DTSEG1    ,DTSEG1"
            BITFLD.LONG 0x00 4.--7. "DBTCR_RSVD    ,DBTCR_RSVD"
            BITFLD.LONG 0x00 0.--3. "DTSEG2    ,DTSEG2"
    GROUP.LONG 0x0018++0x4
        LINE.LONG 0x00 "NBTCR,Nominal Bit Time Control Register"
            BITFLD.LONG 0x00 25.--31. "NSJW    ,NSJW"
            BITFLD.LONG 0x00 16.--24. "NBRP    ,NBRP"
            BITFLD.LONG 0x00 8.--15. "NTSEG1    ,NTSEG1"
            BITFLD.LONG 0x00 7. "NBTCR_RSVD    ,NBTCR_RSVD" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0.--6. "NTSEG2    ,NTSEG2"
    GROUP.LONG 0x001C++0x4
        LINE.LONG 0x00 "ECR,Error Counter Register"
            BITFLD.LONG 0x00 16.--23. "CEL    ,CEL"
            BITFLD.LONG 0x00 15. "ECR_RSVD    ,ECR_RSVD" "0,1"
            BITFLD.LONG 0x00 8.--14. "REC    ,REC"
            BITFLD.LONG 0x00 0.--7. "TEC    ,TEC"
            NEWLINE
    GROUP.LONG 0x0020++0x4
        LINE.LONG 0x00 "PSR,Protocol Status Register"
            BITFLD.LONG 0x00 27. "BO    ,BO" "0,1"
            BITFLD.LONG 0x00 26. "EW    ,EW" "0,1"
            BITFLD.LONG 0x00 25. "EP    ,EP" "0,1"
            BITFLD.LONG 0x00 23.--24. "ACT    ,ACT" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 7.--22. "PSR_RSVD    ,PSR_RSVD"
            BITFLD.LONG 0x00 6. "PXE    ,PXE" "0,1"
            BITFLD.LONG 0x00 5. "RFDF    ,RFDF" "0,1"
            BITFLD.LONG 0x00 4. "RBRS    ,RBRS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "RESI    ,RESI" "0,1"
            BITFLD.LONG 0x00 0.--2. "LEC    ,LEC"
    GROUP.LONG 0x0024++0x4
        LINE.LONG 0x00 "EESR,ECC Error Status Register"
            BITFLD.LONG 0x00 0.--13. "EC    ,EC"
    GROUP.LONG 0x0028++0x4
        LINE.LONG 0x00 "TDCR,Transmitter Delay Compensation Register"
            BITFLD.LONG 0x00 16.--22. "TDCV    ,TDCV"
            BITFLD.LONG 0x00 15. "TDCR_RSVD    ,TDCR_RSVD" "0,1"
            BITFLD.LONG 0x00 8.--14. "TDCO    ,TDCO"
            BITFLD.LONG 0x00 7. "TDCR_RSVD    ,TDCR_RSVD" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0.--6. "TDCF    ,TDCF"
    GROUP.LONG 0x002C++0x4
        LINE.LONG 0x00 "TOCR,Timeout Counter Register"
            BITFLD.LONG 0x00 16.--31. "TOP    ,TOP"
            BITFLD.LONG 0x00 1.--2. "TOS    ,TOS" "0,1,2,3"
            BITFLD.LONG 0x00 0. "TOE    ,TOE" "0,1"
    GROUP.LONG 0x0030++0x4
        LINE.LONG 0x00 "TOCVR,Timeout Counter Value Register"
            BITFLD.LONG 0x00 0.--15. "TOCR    ,TOCR"
    GROUP.LONG 0x0034++0x4
        LINE.LONG 0x00 "IR,Interrupt Register"
            BITFLD.LONG 0x00 25. "TOO    ,TOO" "0,1"
            BITFLD.LONG 0x00 24. "APR    ,APR" "0,1"
            BITFLD.LONG 0x00 23. "PED    ,PED" "0,1"
            BITFLD.LONG 0x00 22. "BO    ,BO" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 21. "EW    ,EW" "0,1"
            BITFLD.LONG 0x00 20. "EP    ,EP" "0,1"
            BITFLD.LONG 0x00 19. "ELO    ,ELO" "0,1"
            BITFLD.LONG 0x00 18. "BEU    ,BEU" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 17. "BEC    ,BEC" "0,1"
            BITFLD.LONG 0x00 16. "MRAF    ,MRAF" "0,1"
            BITFLD.LONG 0x00 15. "TSW    ,TSW" "0,1"
            BITFLD.LONG 0x00 14. "RXBN    ,RXBN" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 13. "RXFL    ,RXFL" "0,1"
            BITFLD.LONG 0x00 12. "RXFF    ,RXFF" "0,1"
            BITFLD.LONG 0x00 11. "RXFW    ,RXFW" "0,1"
            BITFLD.LONG 0x00 10. "RXFE    ,RXFE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 9. "TXBC    ,TXBC" "0,1"
            BITFLD.LONG 0x00 8. "TXBT    ,TXBT" "0,1"
            BITFLD.LONG 0x00 7. "TXFL    ,TXFL" "0,1"
            BITFLD.LONG 0x00 6. "TXFF    ,TXFF" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "TXFW    ,TXFW" "0,1"
            BITFLD.LONG 0x00 4. "TXFE    ,TXFE" "0,1"
            BITFLD.LONG 0x00 3. "TEFL    ,TEFL" "0,1"
            BITFLD.LONG 0x00 2. "TEFF    ,TEFF" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TEFW    ,TEFW" "0,1"
            BITFLD.LONG 0x00 0. "TEFE    ,TEFE" "0,1"
    GROUP.LONG 0x0038++0x4
        LINE.LONG 0x00 "IE,Interrupt Enable"
            BITFLD.LONG 0x00 25. "TOOE    ,TOOE" "0,1"
            BITFLD.LONG 0x00 24. "APRE    ,APRE" "0,1"
            BITFLD.LONG 0x00 23. "PEDE    ,PEDE" "0,1"
            BITFLD.LONG 0x00 22. "BOE    ,BOE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 21. "EWE    ,EWE" "0,1"
            BITFLD.LONG 0x00 20. "EPE    ,EPE" "0,1"
            BITFLD.LONG 0x00 19. "ELOE    ,ELOE" "0,1"
            BITFLD.LONG 0x00 18. "BEUE    ,BEUE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 17. "BECE    ,BECE" "0,1"
            BITFLD.LONG 0x00 16. "MRAFE    ,MRAFE" "0,1"
            BITFLD.LONG 0x00 15. "TSWE    ,TSWE" "0,1"
            BITFLD.LONG 0x00 14. "RXBNE    ,RXBNE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 13. "RXFLE    ,RXFLE" "0,1"
            BITFLD.LONG 0x00 12. "RXFFE    ,RXFFE" "0,1"
            BITFLD.LONG 0x00 11. "RXFWE    ,RXFWE" "0,1"
            BITFLD.LONG 0x00 10. "RXFEE    ,RXFEE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 9. "TXBCE    ,TXBCE" "0,1"
            BITFLD.LONG 0x00 8. "TXBTE    ,TXBTE" "0,1"
            BITFLD.LONG 0x00 7. "TXFLE    ,TXFLE" "0,1"
            BITFLD.LONG 0x00 6. "TXFFE    ,TXFFE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "TXFWE    ,TXFWE" "0,1"
            BITFLD.LONG 0x00 4. "TXFEE    ,TXFEE" "0,1"
            BITFLD.LONG 0x00 3. "TEFLE    ,TEFLE" "0,1"
            BITFLD.LONG 0x00 2. "TEFFE    ,TEFFE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TEFWE    ,TEFWE" "0,1"
            BITFLD.LONG 0x00 0. "TEFEE    ,TEFEE" "0,1"
    GROUP.LONG 0x003C++0x4
        LINE.LONG 0x00 "ILS0R,Interrupt Line Select 0 Register"
            BITFLD.LONG 0x00 20.--21. "TOOLS    ,TOOLS" "0,1,2,3"
            BITFLD.LONG 0x00 18.--19. "APRLS    ,APRLS" "0,1,2,3"
            BITFLD.LONG 0x00 16.--17. "PEDLS    ,PEDLS" "0,1,2,3"
            BITFLD.LONG 0x00 14.--15. "BOLS    ,BOLS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 12.--13. "EWLS    ,EWLS" "0,1,2,3"
            BITFLD.LONG 0x00 10.--11. "EPLS    ,EPLS" "0,1,2,3"
            BITFLD.LONG 0x00 8.--9. "ELOLS    ,ELOLS" "0,1,2,3"
            BITFLD.LONG 0x00 6.--7. "BEULS    ,BEULS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 4.--5. "BECLS    ,BECLS" "0,1,2,3"
            BITFLD.LONG 0x00 2.--3. "MRAFLS    ,MRAFLS" "0,1,2,3"
            BITFLD.LONG 0x00 0.--1. "TSWLS    ,TSWLS" "0,1,2,3"
    GROUP.LONG 0x0040++0x4
        LINE.LONG 0x00 "ILS1R,Interrupt Line Select 1 Register"
            BITFLD.LONG 0x00 28.--29. "RXBNLS    ,RXBNLS" "0,1,2,3"
            BITFLD.LONG 0x00 26.--27. "RXFLLS    ,RXFLLS" "0,1,2,3"
            BITFLD.LONG 0x00 24.--25. "RXFFLS    ,RXFFLS" "0,1,2,3"
            BITFLD.LONG 0x00 22.--23. "RXFWLS    ,RXFWLS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 20.--21. "RXFELS    ,RXFELS" "0,1,2,3"
            BITFLD.LONG 0x00 18.--19. "TXBCLS    ,TXBCLS" "0,1,2,3"
            BITFLD.LONG 0x00 16.--17. "TXBTLS    ,TXBTLS" "0,1,2,3"
            BITFLD.LONG 0x00 14.--15. "TXFLLS    ,TXFLLS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 12.--13. "TXFFLS    ,TXFFLS" "0,1,2,3"
            BITFLD.LONG 0x00 10.--11. "TXFWLS    ,TXFWLS" "0,1,2,3"
            BITFLD.LONG 0x00 8.--9. "TXFELS    ,TXFELS" "0,1,2,3"
            BITFLD.LONG 0x00 6.--7. "TEFLLS    ,TEFLLS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 4.--5. "TEFFLS    ,TEFFLS" "0,1,2,3"
            BITFLD.LONG 0x00 2.--3. "TEFWLS    ,TEFWLS" "0,1,2,3"
            BITFLD.LONG 0x00 0.--1. "TEFELS    ,TEFELS" "0,1,2,3"
    GROUP.LONG 0x0044++0x4
        LINE.LONG 0x00 "ILE,Interrupt Line Enable"
            BITFLD.LONG 0x00 3. "EINT3    ,EINT3" "0,1"
            BITFLD.LONG 0x00 2. "EINT2    ,EINT2" "0,1"
            BITFLD.LONG 0x00 1. "EINT1    ,EINT1" "0,1"
            BITFLD.LONG 0x00 0. "EINT0    ,EINT0" "0,1"
            NEWLINE
    GROUP.LONG 0x0048++0x4
        LINE.LONG 0x00 "IDFCR,ID Filter Control Register"
            BITFLD.LONG 0x00 25. "RNMFE    ,RNMFE" "0,1"
            BITFLD.LONG 0x00 24. "RRFE    ,RRFE" "0,1"
            BITFLD.LONG 0x00 16.--23. "XIDFS    ,XIDFS"
            BITFLD.LONG 0x00 10.--15. "IDFCR_RSVD    ,IDFCR_RSVD"
            NEWLINE
            BITFLD.LONG 0x00 9. "RNMFS    ,RNMFS" "0,1"
            BITFLD.LONG 0x00 8. "RRFS    ,RRFS" "0,1"
            BITFLD.LONG 0x00 0.--7. "SIDFS    ,SIDFS"
    GROUP.LONG 0x004C++0x4
        LINE.LONG 0x00 "XIDAMR,Extended ID AND Mask Register"
            HEXMASK.LONG 0x00 0.--28. "EIDM    ,EIDM"
    GROUP.LONG 0x0050++0x4
        LINE.LONG 0x00 "RXESCR,RX Buffer / FIFO Element Size Configuration Register"
            BITFLD.LONG 0x00 4.--6. "RXFDS    ,RXFDS"
            BITFLD.LONG 0x00 3. "RXESCR_RSVD    ,RXESCR_RSVD" "0,1"
            BITFLD.LONG 0x00 0.--2. "RXBDS    ,RXBDS"
    GROUP.LONG 0x0054++0x4
        LINE.LONG 0x00 "RXBS0R,RX Buffer Status 0 Register"
            BITFLD.LONG 0x00 0.--31. "ND0    ,ND0"
    GROUP.LONG 0x0058++0x4
        LINE.LONG 0x00 "RXBS1R,RX Buffer Status 1 Register"
            BITFLD.LONG 0x00 0.--31. "ND1    ,ND1"
    GROUP.LONG 0x005C++0x4
        LINE.LONG 0x00 "RXFCFGR,RX FIFO Configuration Register"
            BITFLD.LONG 0x00 24.--31. "RXFWM    ,RXFWM"
            BITFLD.LONG 0x00 16.--23. "RXFSZ    ,RXFSZ"
            BITFLD.LONG 0x00 1.--15. "RXFCFGR_RSVD    ,RXFCFGR_RSVD"
            BITFLD.LONG 0x00 0. "RXFOPM    ,RXFOPM" "0,1"
            NEWLINE
    GROUP.LONG 0x0060++0x4
        LINE.LONG 0x00 "RXFSTAR,RX FIFO Status Register"
            BITFLD.LONG 0x00 24.--31. "RXFPI    ,RXFPI"
            BITFLD.LONG 0x00 16.--23. "RXFGI    ,RXFGI"
            BITFLD.LONG 0x00 8.--15. "RXFLV    ,RXFLV"
            BITFLD.LONG 0x00 7. "RXFML    ,RXFML" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "RXFF    ,RXFF" "0,1"
            BITFLD.LONG 0x00 5. "RXFE    ,RXFE" "0,1"
            BITFLD.LONG 0x00 1.--4. "RXFSTAR_RSVD    ,RXFSTAR_RSVD"
            BITFLD.LONG 0x00 0. "RXFACK    ,RXFACK" "0,1"
            NEWLINE
    GROUP.LONG 0x0064++0x4
        LINE.LONG 0x00 "TXESCR,TX Buffer / FIFO Element Size Configuration Register"
            BITFLD.LONG 0x00 4.--6. "TXFDS    ,TXFDS"
            BITFLD.LONG 0x00 3. "TXESCR_RSVD    ,TXESCR_RSVD" "0,1"
            BITFLD.LONG 0x00 0.--2. "TXBDS    ,TXBDS"
    GROUP.LONG 0x0068++0x4
        LINE.LONG 0x00 "TXBRPR0,TX Buffer Request Pending Register 0"
            BITFLD.LONG 0x00 0.--31. "TRP0    ,TRP0"
    GROUP.LONG 0x006C++0x4
        LINE.LONG 0x00 "TXBRPR1,TX Buffer Request Pending Register 1"
            BITFLD.LONG 0x00 0.--31. "TRP1    ,TRP1"
    GROUP.LONG 0x0070++0x4
        LINE.LONG 0x00 "TXBARR0,TX Buffer Add Request Register 0"
            BITFLD.LONG 0x00 0.--31. "AR0    ,AR0"
    GROUP.LONG 0x0074++0x4
        LINE.LONG 0x00 "TXBARR1,TX Buffer Add Request Register 1"
            BITFLD.LONG 0x00 0.--31. "AR1    ,AR1"
    GROUP.LONG 0x0078++0x4
        LINE.LONG 0x00 "TXBCRR0,TX Buffer Cancellation Request Register 0"
            BITFLD.LONG 0x00 0.--31. "CR0    ,CR0"
    GROUP.LONG 0x007C++0x4
        LINE.LONG 0x00 "TXBCRR1,TX Buffer Cancellation Request Register 1"
            BITFLD.LONG 0x00 0.--31. "CR1    ,CR1"
    GROUP.LONG 0x0080++0x4
        LINE.LONG 0x00 "TXBTOR0,TX Buffer Transmission Occurred Register 0"
            BITFLD.LONG 0x00 0.--31. "TO0    ,TO0"
    GROUP.LONG 0x0084++0x4
        LINE.LONG 0x00 "TXBTOR1,TX Buffer Transmission Occurred Register 1"
            BITFLD.LONG 0x00 0.--31. "TO1    ,TO1"
    GROUP.LONG 0x0088++0x4
        LINE.LONG 0x00 "TXBCFR0,TX Buffer Cancellation Finished Register 0"
            BITFLD.LONG 0x00 0.--31. "CF0    ,CF0"
    GROUP.LONG 0x008C++0x4
        LINE.LONG 0x00 "TXBCFR1,TX Buffer Cancellation Finished Register 1"
            BITFLD.LONG 0x00 0.--31. "CF1    ,CF1"
    GROUP.LONG 0x0090++0x4
        LINE.LONG 0x00 "TXBTIER0,TX Buffer Transmission Interrupt Enable Register 0"
            BITFLD.LONG 0x00 0.--31. "TIE0    ,TIE0"
    GROUP.LONG 0x0094++0x4
        LINE.LONG 0x00 "TXBTIER1,TX Buffer Transmission Interrupt Enable Register 1"
            BITFLD.LONG 0x00 0.--31. "TIE1    ,TIE1"
    GROUP.LONG 0x0098++0x4
        LINE.LONG 0x00 "TXBCIER0,TX Buffer Cancellation Finished Interrupt Enable Register 0"
            BITFLD.LONG 0x00 0.--31. "CFIE0    ,CFIE0"
    GROUP.LONG 0x009C++0x4
        LINE.LONG 0x00 "TXBCIER1,TX Buffer Cancellation Finished Interrupt Enable Register 1"
            BITFLD.LONG 0x00 0.--31. "CFIE1    ,CFIE1"
    GROUP.LONG 0x00A0++0x4
        LINE.LONG 0x00 "TXFCFGR,TX FIFO Configuration Register"
            BITFLD.LONG 0x00 24.--31. "TXFWM    ,TXFWM"
            BITFLD.LONG 0x00 16.--23. "TXFSZ    ,TXFSZ"
            BITFLD.LONG 0x00 1.--15. "TXFCFGR_RSVD    ,TXFCFGR_RSVD"
            BITFLD.LONG 0x00 0. "TXFOPM    ,TXFOPM" "0,1"
            NEWLINE
    GROUP.LONG 0x00A4++0x4
        LINE.LONG 0x00 "TXFSTAR,TX FIFO Status Register"
            BITFLD.LONG 0x00 24.--31. "TXFPI    ,TXFPI"
            BITFLD.LONG 0x00 16.--23. "TXFGI    ,TXFGI"
            BITFLD.LONG 0x00 8.--15. "TXFLV    ,TXFLV"
            BITFLD.LONG 0x00 7. "TXFML    ,TXFML" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "TXFF    ,TXFF" "0,1"
            BITFLD.LONG 0x00 5. "TXFE    ,TXFE" "0,1"
            BITFLD.LONG 0x00 1.--4. "TXFSTAR_RSVD    ,TXFSTAR_RSVD"
            BITFLD.LONG 0x00 0. "TXFACK    ,TXFACK" "0,1"
            NEWLINE
    GROUP.LONG 0x00A8++0x4
        LINE.LONG 0x00 "TXEFCFGR,TX Event FIFO Configuration Register"
            BITFLD.LONG 0x00 24.--31. "TEFWM    ,TEFWM"
            BITFLD.LONG 0x00 16.--23. "TEFSZ    ,TEFSZ"
            BITFLD.LONG 0x00 1.--15. "TXEFCFGR_RSVD    ,TXEFCFGR_RSVD"
            BITFLD.LONG 0x00 0. "TEFOPM    ,TEFOPM" "0,1"
            NEWLINE
    GROUP.LONG 0x00AC++0x4
        LINE.LONG 0x00 "TXEFSTAR,TX Event FIFO Status Register"
            BITFLD.LONG 0x00 24.--31. "TEFPI    ,TEFPI"
            BITFLD.LONG 0x00 16.--23. "TEFGI    ,TEFGI"
            BITFLD.LONG 0x00 8.--15. "TEFLV    ,TEFLV"
            BITFLD.LONG 0x00 7. "TEFML    ,TEFML" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "TEFF    ,TEFF" "0,1"
            BITFLD.LONG 0x00 5. "TEFE    ,TEFE" "0,1"
            BITFLD.LONG 0x00 1.--4. "TXEFSTAR_RSVD    ,TXEFSTAR_RSVD"
            BITFLD.LONG 0x00 0. "TEFACK    ,TEFACK" "0,1"
            NEWLINE
    GROUP.LONG 0x00B0++0x4
        LINE.LONG 0x00 "RXFELMR0,RX FIFO Element Register 0"
            BITFLD.LONG 0x00 0.--31. "HEAD0    ,HEAD0"
    GROUP.LONG 0x00B4++0x4
        LINE.LONG 0x00 "RXFELMR1,RX FIFO Element Register 1"
            BITFLD.LONG 0x00 0.--31. "HEAD1    ,HEAD1"
    GROUP.LONG 0x00B8++0x4
        LINE.LONG 0x00 "RXFELMR2,RX FIFO Element Register 2"
            BITFLD.LONG 0x00 0.--31. "DATA0    ,DATA0"
    GROUP.LONG 0x00BC++0x4
        LINE.LONG 0x00 "RXFELMR3,RX FIFO Element Register 3"
            BITFLD.LONG 0x00 0.--31. "DATA1    ,DATA1"
    GROUP.LONG 0x00C0++0x4
        LINE.LONG 0x00 "RXFELMR4,RX FIFO Element Register 4"
            BITFLD.LONG 0x00 0.--31. "DATA2    ,DATA2"
    GROUP.LONG 0x00C4++0x4
        LINE.LONG 0x00 "RXFELMR5,RX FIFO Element Register 5"
            BITFLD.LONG 0x00 0.--31. "DATA3    ,DATA3"
    GROUP.LONG 0x00C8++0x4
        LINE.LONG 0x00 "RXFELMR6,RX FIFO Element Register 6"
            BITFLD.LONG 0x00 0.--31. "DATA4    ,DATA4"
    GROUP.LONG 0x00CC++0x4
        LINE.LONG 0x00 "RXFELMR7,RX FIFO Element Register 7"
            BITFLD.LONG 0x00 0.--31. "DATA5    ,DATA5"
    GROUP.LONG 0x00D0++0x4
        LINE.LONG 0x00 "RXFELMR8,RX FIFO Element Register 8"
            BITFLD.LONG 0x00 0.--31. "DATA6    ,DATA6"
    GROUP.LONG 0x00D4++0x4
        LINE.LONG 0x00 "RXFELMR9,RX FIFO Element Register 9"
            BITFLD.LONG 0x00 0.--31. "DATA7    ,DATA7"
    GROUP.LONG 0x00D8++0x4
        LINE.LONG 0x00 "RXFELMR10,RX FIFO Element Register 10"
            BITFLD.LONG 0x00 0.--31. "DATA8    ,DATA8"
    GROUP.LONG 0x00DC++0x4
        LINE.LONG 0x00 "RXFELMR11,RX FIFO Element Register 11"
            BITFLD.LONG 0x00 0.--31. "DATA9    ,DATA9"
    GROUP.LONG 0x00E0++0x4
        LINE.LONG 0x00 "RXFELMR12,RX FIFO Element Register 12"
            BITFLD.LONG 0x00 0.--31. "DATA10    ,DATA10"
    GROUP.LONG 0x00E4++0x4
        LINE.LONG 0x00 "RXFELMR13,RX FIFO Element Register 13"
            BITFLD.LONG 0x00 0.--31. "DATA11    ,DATA11"
    GROUP.LONG 0x00E8++0x4
        LINE.LONG 0x00 "RXFELMR14,RX FIFO Element Register 14"
            BITFLD.LONG 0x00 0.--31. "DATA12    ,DATA12"
    GROUP.LONG 0x00EC++0x4
        LINE.LONG 0x00 "RXFELMR15,RX FIFO Element Register 15"
            BITFLD.LONG 0x00 0.--31. "DATA13    ,DATA13"
    GROUP.LONG 0x00F0++0x4
        LINE.LONG 0x00 "RXFELMR16,RX FIFO Element Register 16"
            BITFLD.LONG 0x00 0.--31. "DATA14    ,DATA14"
    GROUP.LONG 0x00F4++0x4
        LINE.LONG 0x00 "RXFELMR17,RX FIFO Element Register 17"
            BITFLD.LONG 0x00 0.--31. "DATA15    ,DATA15"
    GROUP.LONG 0x00F8++0x4
        LINE.LONG 0x00 "TXFELMR0,TX FIFO Element Register 0"
            BITFLD.LONG 0x00 0.--31. "HEAD0    ,HEAD0"
    GROUP.LONG 0x00FC++0x4
        LINE.LONG 0x00 "TXFELMR1,TX FIFO Element Register 1"
            BITFLD.LONG 0x00 0.--31. "HEAD1    ,HEAD1"
    GROUP.LONG 0x0100++0x4
        LINE.LONG 0x00 "TXFELMR2,TX FIFO Element Register 2"
            BITFLD.LONG 0x00 0.--31. "DATA0    ,DATA0"
    GROUP.LONG 0x0104++0x4
        LINE.LONG 0x00 "TXFELMR3,TX FIFO Element Register 3"
            BITFLD.LONG 0x00 0.--31. "DATA1    ,DATA1"
    GROUP.LONG 0x0108++0x4
        LINE.LONG 0x00 "TXFELMR4,TX FIFO Element Register 4"
            BITFLD.LONG 0x00 0.--31. "DATA2    ,DATA2"
    GROUP.LONG 0x010C++0x4
        LINE.LONG 0x00 "TXFELMR5,TX FIFO Element Register 5"
            BITFLD.LONG 0x00 0.--31. "DATA3    ,DATA3"
    GROUP.LONG 0x0110++0x4
        LINE.LONG 0x00 "TXFELMR6,TX FIFO Element Register 6"
            BITFLD.LONG 0x00 0.--31. "DATA4    ,DATA4"
    GROUP.LONG 0x0114++0x4
        LINE.LONG 0x00 "TXFELMR7,TX FIFO Element Register 7"
            BITFLD.LONG 0x00 0.--31. "DATA5    ,DATA5"
    GROUP.LONG 0x0118++0x4
        LINE.LONG 0x00 "TXFELMR8,TX FIFO Element Register 8"
            BITFLD.LONG 0x00 0.--31. "DATA6    ,DATA6"
    GROUP.LONG 0x011C++0x4
        LINE.LONG 0x00 "TXFELMR9,TX FIFO Element Register 9"
            BITFLD.LONG 0x00 0.--31. "DATA7    ,DATA7"
    GROUP.LONG 0x0120++0x4
        LINE.LONG 0x00 "TXFELMR10,TX FIFO Element Register 10"
            BITFLD.LONG 0x00 0.--31. "DATA8    ,DATA8"
    GROUP.LONG 0x0124++0x4
        LINE.LONG 0x00 "TXFELMR11,TX FIFO Element Register 11"
            BITFLD.LONG 0x00 0.--31. "DATA9    ,DATA9"
    GROUP.LONG 0x0128++0x4
        LINE.LONG 0x00 "TXFELMR12,TX FIFO Element Register 12"
            BITFLD.LONG 0x00 0.--31. "DATA10    ,DATA10"
    GROUP.LONG 0x012C++0x4
        LINE.LONG 0x00 "TXFELMR13,TX FIFO Element Register 13"
            BITFLD.LONG 0x00 0.--31. "DATA11    ,DATA11"
    GROUP.LONG 0x0130++0x4
        LINE.LONG 0x00 "TXFELMR14,TX FIFO Element Register 14"
            BITFLD.LONG 0x00 0.--31. "DATA12    ,DATA12"
    GROUP.LONG 0x0134++0x4
        LINE.LONG 0x00 "TXFELMR15,TX FIFO Element Register 15"
            BITFLD.LONG 0x00 0.--31. "DATA13    ,DATA13"
    GROUP.LONG 0x0138++0x4
        LINE.LONG 0x00 "TXFELMR16,TX FIFO Element Register 16"
            BITFLD.LONG 0x00 0.--31. "DATA14    ,DATA14"
    GROUP.LONG 0x013C++0x4
        LINE.LONG 0x00 "TXFELMR17,TX FIFO Element Register 17"
            BITFLD.LONG 0x00 0.--31. "DATA15    ,DATA15"
    GROUP.LONG 0x0140++0x4
        LINE.LONG 0x00 "TXEFELMR0,TX Event FIFO Element Register 0"
            BITFLD.LONG 0x00 0.--31. "HEAD0    ,HEAD0"
    GROUP.LONG 0x0144++0x03
        LINE.LONG 0x00 "TXEFELMR1,TX Event FIFO Element Register 1"
            BITFLD.LONG 0x00 0.--31. "HEAD1    ,HEAD1"
TREE.END
TREE "CAN1 Registers"
    BASE ad:0xbc0000
    GROUP.LONG 0x0000++0x4
        LINE.LONG 0x00 "CRR, Core Release Register"
            BITFLD.LONG 0x00 0.--31. "VER    ,VER"
    GROUP.LONG 0x0004++0x4
        LINE.LONG 0x00 "MCR,Mode Control Register"
            BITFLD.LONG 0x00 18. "TDENA    ,TDENA" "0,1"
            BITFLD.LONG 0x00 17. "RDENA    ,RDENA" "0,1"
            BITFLD.LONG 0x00 16. "ECCENA    ,ECCENA" "0,1"
            BITFLD.LONG 0x00 11.--15. "MCR_RSVD    ,MCR_RSVD"
            NEWLINE
            BITFLD.LONG 0x00 10. "TESTRX    ,TESTRX" "0,1"
            BITFLD.LONG 0x00 8.--9. "TESTTX    ,TESTTX" "0,1,2,3"
            BITFLD.LONG 0x00 7. "TEST    ,TEST" "0,1"
            BITFLD.LONG 0x00 6. "SLEEP    ,SLEEP" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "SPACK    ,SPACK" "0,1"
            BITFLD.LONG 0x00 4. "ROPT    ,ROPT" "0,1"
            BITFLD.LONG 0x00 3. "MON    ,MON" "0,1"
            BITFLD.LONG 0x00 2. "LBACK    ,LBACK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "CFG    ,CFG" "0,1"
            BITFLD.LONG 0x00 0. "RESET    ,RESET" "0,1"
    GROUP.LONG 0x0008++0x4
        LINE.LONG 0x00 "PCR,Protocol Control Register"
            BITFLD.LONG 0x00 31. "FDD    ,FDD" "0,1"
            BITFLD.LONG 0x00 4.--30. "PCR_RSVD    ,PCR_RSVD"
            BITFLD.LONG 0x00 3. "FDO    ,FDO" "0,1"
            BITFLD.LONG 0x00 2. "BRS    ,BRS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TDC    ,TDC" "0,1"
            BITFLD.LONG 0x00 0. "ART    ,ART" "0,1"
    GROUP.LONG 0x000C++0x4
        LINE.LONG 0x00 "TSCCR,Timestamp Counter Configuration Register"
            BITFLD.LONG 0x00 16.--19. "TSCP    ,TSCP"
            BITFLD.LONG 0x00 2.--15. "TSCCR_RSVD    ,TSCCR_RSVD"
            BITFLD.LONG 0x00 0.--1. "TSCM    ,TSCM" "0,1,2,3"
    GROUP.LONG 0x0010++0x4
        LINE.LONG 0x00 "TSCVR,Timestamp Counter Value Register"
            BITFLD.LONG 0x00 0.--15. "TSC    ,TSC"
    GROUP.LONG 0x0014++0x4
        LINE.LONG 0x00 "DBTCR,Data Bit Time Control Register"
            BITFLD.LONG 0x00 24.--27. "DSJW    ,DSJW"
            BITFLD.LONG 0x00 21.--23. "DBTCR_RSVD    ,DBTCR_RSVD"
            BITFLD.LONG 0x00 16.--20. "DBRP    ,DBRP"
            BITFLD.LONG 0x00 13.--15. "DBTCR_RSVD    ,DBTCR_RSVD"
            NEWLINE
            BITFLD.LONG 0x00 8.--12. "DTSEG1    ,DTSEG1"
            BITFLD.LONG 0x00 4.--7. "DBTCR_RSVD    ,DBTCR_RSVD"
            BITFLD.LONG 0x00 0.--3. "DTSEG2    ,DTSEG2"
    GROUP.LONG 0x0018++0x4
        LINE.LONG 0x00 "NBTCR,Nominal Bit Time Control Register"
            BITFLD.LONG 0x00 25.--31. "NSJW    ,NSJW"
            BITFLD.LONG 0x00 16.--24. "NBRP    ,NBRP"
            BITFLD.LONG 0x00 8.--15. "NTSEG1    ,NTSEG1"
            BITFLD.LONG 0x00 7. "NBTCR_RSVD    ,NBTCR_RSVD" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0.--6. "NTSEG2    ,NTSEG2"
    GROUP.LONG 0x001C++0x4
        LINE.LONG 0x00 "ECR,Error Counter Register"
            BITFLD.LONG 0x00 16.--23. "CEL    ,CEL"
            BITFLD.LONG 0x00 15. "ECR_RSVD    ,ECR_RSVD" "0,1"
            BITFLD.LONG 0x00 8.--14. "REC    ,REC"
            BITFLD.LONG 0x00 0.--7. "TEC    ,TEC"
            NEWLINE
    GROUP.LONG 0x0020++0x4
        LINE.LONG 0x00 "PSR,Protocol Status Register"
            BITFLD.LONG 0x00 27. "BO    ,BO" "0,1"
            BITFLD.LONG 0x00 26. "EW    ,EW" "0,1"
            BITFLD.LONG 0x00 25. "EP    ,EP" "0,1"
            BITFLD.LONG 0x00 23.--24. "ACT    ,ACT" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 7.--22. "PSR_RSVD    ,PSR_RSVD"
            BITFLD.LONG 0x00 6. "PXE    ,PXE" "0,1"
            BITFLD.LONG 0x00 5. "RFDF    ,RFDF" "0,1"
            BITFLD.LONG 0x00 4. "RBRS    ,RBRS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "RESI    ,RESI" "0,1"
            BITFLD.LONG 0x00 0.--2. "LEC    ,LEC"
    GROUP.LONG 0x0024++0x4
        LINE.LONG 0x00 "EESR,ECC Error Status Register"
            BITFLD.LONG 0x00 0.--13. "EC    ,EC"
    GROUP.LONG 0x0028++0x4
        LINE.LONG 0x00 "TDCR,Transmitter Delay Compensation Register"
            BITFLD.LONG 0x00 16.--22. "TDCV    ,TDCV"
            BITFLD.LONG 0x00 15. "TDCR_RSVD    ,TDCR_RSVD" "0,1"
            BITFLD.LONG 0x00 8.--14. "TDCO    ,TDCO"
            BITFLD.LONG 0x00 7. "TDCR_RSVD    ,TDCR_RSVD" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0.--6. "TDCF    ,TDCF"
    GROUP.LONG 0x002C++0x4
        LINE.LONG 0x00 "TOCR,Timeout Counter Register"
            BITFLD.LONG 0x00 16.--31. "TOP    ,TOP"
            BITFLD.LONG 0x00 1.--2. "TOS    ,TOS" "0,1,2,3"
            BITFLD.LONG 0x00 0. "TOE    ,TOE" "0,1"
    GROUP.LONG 0x0030++0x4
        LINE.LONG 0x00 "TOCVR,Timeout Counter Value Register"
            BITFLD.LONG 0x00 0.--15. "TOCR    ,TOCR"
    GROUP.LONG 0x0034++0x4
        LINE.LONG 0x00 "IR,Interrupt Register"
            BITFLD.LONG 0x00 25. "TOO    ,TOO" "0,1"
            BITFLD.LONG 0x00 24. "APR    ,APR" "0,1"
            BITFLD.LONG 0x00 23. "PED    ,PED" "0,1"
            BITFLD.LONG 0x00 22. "BO    ,BO" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 21. "EW    ,EW" "0,1"
            BITFLD.LONG 0x00 20. "EP    ,EP" "0,1"
            BITFLD.LONG 0x00 19. "ELO    ,ELO" "0,1"
            BITFLD.LONG 0x00 18. "BEU    ,BEU" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 17. "BEC    ,BEC" "0,1"
            BITFLD.LONG 0x00 16. "MRAF    ,MRAF" "0,1"
            BITFLD.LONG 0x00 15. "TSW    ,TSW" "0,1"
            BITFLD.LONG 0x00 14. "RXBN    ,RXBN" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 13. "RXFL    ,RXFL" "0,1"
            BITFLD.LONG 0x00 12. "RXFF    ,RXFF" "0,1"
            BITFLD.LONG 0x00 11. "RXFW    ,RXFW" "0,1"
            BITFLD.LONG 0x00 10. "RXFE    ,RXFE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 9. "TXBC    ,TXBC" "0,1"
            BITFLD.LONG 0x00 8. "TXBT    ,TXBT" "0,1"
            BITFLD.LONG 0x00 7. "TXFL    ,TXFL" "0,1"
            BITFLD.LONG 0x00 6. "TXFF    ,TXFF" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "TXFW    ,TXFW" "0,1"
            BITFLD.LONG 0x00 4. "TXFE    ,TXFE" "0,1"
            BITFLD.LONG 0x00 3. "TEFL    ,TEFL" "0,1"
            BITFLD.LONG 0x00 2. "TEFF    ,TEFF" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TEFW    ,TEFW" "0,1"
            BITFLD.LONG 0x00 0. "TEFE    ,TEFE" "0,1"
    GROUP.LONG 0x0038++0x4
        LINE.LONG 0x00 "IE,Interrupt Enable"
            BITFLD.LONG 0x00 25. "TOOE    ,TOOE" "0,1"
            BITFLD.LONG 0x00 24. "APRE    ,APRE" "0,1"
            BITFLD.LONG 0x00 23. "PEDE    ,PEDE" "0,1"
            BITFLD.LONG 0x00 22. "BOE    ,BOE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 21. "EWE    ,EWE" "0,1"
            BITFLD.LONG 0x00 20. "EPE    ,EPE" "0,1"
            BITFLD.LONG 0x00 19. "ELOE    ,ELOE" "0,1"
            BITFLD.LONG 0x00 18. "BEUE    ,BEUE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 17. "BECE    ,BECE" "0,1"
            BITFLD.LONG 0x00 16. "MRAFE    ,MRAFE" "0,1"
            BITFLD.LONG 0x00 15. "TSWE    ,TSWE" "0,1"
            BITFLD.LONG 0x00 14. "RXBNE    ,RXBNE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 13. "RXFLE    ,RXFLE" "0,1"
            BITFLD.LONG 0x00 12. "RXFFE    ,RXFFE" "0,1"
            BITFLD.LONG 0x00 11. "RXFWE    ,RXFWE" "0,1"
            BITFLD.LONG 0x00 10. "RXFEE    ,RXFEE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 9. "TXBCE    ,TXBCE" "0,1"
            BITFLD.LONG 0x00 8. "TXBTE    ,TXBTE" "0,1"
            BITFLD.LONG 0x00 7. "TXFLE    ,TXFLE" "0,1"
            BITFLD.LONG 0x00 6. "TXFFE    ,TXFFE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "TXFWE    ,TXFWE" "0,1"
            BITFLD.LONG 0x00 4. "TXFEE    ,TXFEE" "0,1"
            BITFLD.LONG 0x00 3. "TEFLE    ,TEFLE" "0,1"
            BITFLD.LONG 0x00 2. "TEFFE    ,TEFFE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TEFWE    ,TEFWE" "0,1"
            BITFLD.LONG 0x00 0. "TEFEE    ,TEFEE" "0,1"
    GROUP.LONG 0x003C++0x4
        LINE.LONG 0x00 "ILS0R,Interrupt Line Select 0 Register"
            BITFLD.LONG 0x00 20.--21. "TOOLS    ,TOOLS" "0,1,2,3"
            BITFLD.LONG 0x00 18.--19. "APRLS    ,APRLS" "0,1,2,3"
            BITFLD.LONG 0x00 16.--17. "PEDLS    ,PEDLS" "0,1,2,3"
            BITFLD.LONG 0x00 14.--15. "BOLS    ,BOLS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 12.--13. "EWLS    ,EWLS" "0,1,2,3"
            BITFLD.LONG 0x00 10.--11. "EPLS    ,EPLS" "0,1,2,3"
            BITFLD.LONG 0x00 8.--9. "ELOLS    ,ELOLS" "0,1,2,3"
            BITFLD.LONG 0x00 6.--7. "BEULS    ,BEULS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 4.--5. "BECLS    ,BECLS" "0,1,2,3"
            BITFLD.LONG 0x00 2.--3. "MRAFLS    ,MRAFLS" "0,1,2,3"
            BITFLD.LONG 0x00 0.--1. "TSWLS    ,TSWLS" "0,1,2,3"
    GROUP.LONG 0x0040++0x4
        LINE.LONG 0x00 "ILS1R,Interrupt Line Select 1 Register"
            BITFLD.LONG 0x00 28.--29. "RXBNLS    ,RXBNLS" "0,1,2,3"
            BITFLD.LONG 0x00 26.--27. "RXFLLS    ,RXFLLS" "0,1,2,3"
            BITFLD.LONG 0x00 24.--25. "RXFFLS    ,RXFFLS" "0,1,2,3"
            BITFLD.LONG 0x00 22.--23. "RXFWLS    ,RXFWLS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 20.--21. "RXFELS    ,RXFELS" "0,1,2,3"
            BITFLD.LONG 0x00 18.--19. "TXBCLS    ,TXBCLS" "0,1,2,3"
            BITFLD.LONG 0x00 16.--17. "TXBTLS    ,TXBTLS" "0,1,2,3"
            BITFLD.LONG 0x00 14.--15. "TXFLLS    ,TXFLLS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 12.--13. "TXFFLS    ,TXFFLS" "0,1,2,3"
            BITFLD.LONG 0x00 10.--11. "TXFWLS    ,TXFWLS" "0,1,2,3"
            BITFLD.LONG 0x00 8.--9. "TXFELS    ,TXFELS" "0,1,2,3"
            BITFLD.LONG 0x00 6.--7. "TEFLLS    ,TEFLLS" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 4.--5. "TEFFLS    ,TEFFLS" "0,1,2,3"
            BITFLD.LONG 0x00 2.--3. "TEFWLS    ,TEFWLS" "0,1,2,3"
            BITFLD.LONG 0x00 0.--1. "TEFELS    ,TEFELS" "0,1,2,3"
    GROUP.LONG 0x0044++0x4
        LINE.LONG 0x00 "ILE,Interrupt Line Enable"
            BITFLD.LONG 0x00 3. "EINT3    ,EINT3" "0,1"
            BITFLD.LONG 0x00 2. "EINT2    ,EINT2" "0,1"
            BITFLD.LONG 0x00 1. "EINT1    ,EINT1" "0,1"
            BITFLD.LONG 0x00 0. "EINT0    ,EINT0" "0,1"
            NEWLINE
    GROUP.LONG 0x0048++0x4
        LINE.LONG 0x00 "IDFCR,ID Filter Control Register"
            BITFLD.LONG 0x00 25. "RNMFE    ,RNMFE" "0,1"
            BITFLD.LONG 0x00 24. "RRFE    ,RRFE" "0,1"
            BITFLD.LONG 0x00 16.--23. "XIDFS    ,XIDFS"
            BITFLD.LONG 0x00 10.--15. "IDFCR_RSVD    ,IDFCR_RSVD"
            NEWLINE
            BITFLD.LONG 0x00 9. "RNMFS    ,RNMFS" "0,1"
            BITFLD.LONG 0x00 8. "RRFS    ,RRFS" "0,1"
            BITFLD.LONG 0x00 0.--7. "SIDFS    ,SIDFS"
    GROUP.LONG 0x004C++0x4
        LINE.LONG 0x00 "XIDAMR,Extended ID AND Mask Register"
            HEXMASK.LONG 0x00 0.--28. "EIDM    ,EIDM"
    GROUP.LONG 0x0050++0x4
        LINE.LONG 0x00 "RXESCR,RX Buffer / FIFO Element Size Configuration Register"
            BITFLD.LONG 0x00 4.--6. "RXFDS    ,RXFDS"
            BITFLD.LONG 0x00 3. "RXESCR_RSVD    ,RXESCR_RSVD" "0,1"
            BITFLD.LONG 0x00 0.--2. "RXBDS    ,RXBDS"
    GROUP.LONG 0x0054++0x4
        LINE.LONG 0x00 "RXBS0R,RX Buffer Status 0 Register"
            BITFLD.LONG 0x00 0.--31. "ND0    ,ND0"
    GROUP.LONG 0x0058++0x4
        LINE.LONG 0x00 "RXBS1R,RX Buffer Status 1 Register"
            BITFLD.LONG 0x00 0.--31. "ND1    ,ND1"
    GROUP.LONG 0x005C++0x4
        LINE.LONG 0x00 "RXFCFGR,RX FIFO Configuration Register"
            BITFLD.LONG 0x00 24.--31. "RXFWM    ,RXFWM"
            BITFLD.LONG 0x00 16.--23. "RXFSZ    ,RXFSZ"
            BITFLD.LONG 0x00 1.--15. "RXFCFGR_RSVD    ,RXFCFGR_RSVD"
            BITFLD.LONG 0x00 0. "RXFOPM    ,RXFOPM" "0,1"
            NEWLINE
    GROUP.LONG 0x0060++0x4
        LINE.LONG 0x00 "RXFSTAR,RX FIFO Status Register"
            BITFLD.LONG 0x00 24.--31. "RXFPI    ,RXFPI"
            BITFLD.LONG 0x00 16.--23. "RXFGI    ,RXFGI"
            BITFLD.LONG 0x00 8.--15. "RXFLV    ,RXFLV"
            BITFLD.LONG 0x00 7. "RXFML    ,RXFML" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "RXFF    ,RXFF" "0,1"
            BITFLD.LONG 0x00 5. "RXFE    ,RXFE" "0,1"
            BITFLD.LONG 0x00 1.--4. "RXFSTAR_RSVD    ,RXFSTAR_RSVD"
            BITFLD.LONG 0x00 0. "RXFACK    ,RXFACK" "0,1"
            NEWLINE
    GROUP.LONG 0x0064++0x4
        LINE.LONG 0x00 "TXESCR,TX Buffer / FIFO Element Size Configuration Register"
            BITFLD.LONG 0x00 4.--6. "TXFDS    ,TXFDS"
            BITFLD.LONG 0x00 3. "TXESCR_RSVD    ,TXESCR_RSVD" "0,1"
            BITFLD.LONG 0x00 0.--2. "TXBDS    ,TXBDS"
    GROUP.LONG 0x0068++0x4
        LINE.LONG 0x00 "TXBRPR0,TX Buffer Request Pending Register 0"
            BITFLD.LONG 0x00 0.--31. "TRP0    ,TRP0"
    GROUP.LONG 0x006C++0x4
        LINE.LONG 0x00 "TXBRPR1,TX Buffer Request Pending Register 1"
            BITFLD.LONG 0x00 0.--31. "TRP1    ,TRP1"
    GROUP.LONG 0x0070++0x4
        LINE.LONG 0x00 "TXBARR0,TX Buffer Add Request Register 0"
            BITFLD.LONG 0x00 0.--31. "AR0    ,AR0"
    GROUP.LONG 0x0074++0x4
        LINE.LONG 0x00 "TXBARR1,TX Buffer Add Request Register 1"
            BITFLD.LONG 0x00 0.--31. "AR1    ,AR1"
    GROUP.LONG 0x0078++0x4
        LINE.LONG 0x00 "TXBCRR0,TX Buffer Cancellation Request Register 0"
            BITFLD.LONG 0x00 0.--31. "CR0    ,CR0"
    GROUP.LONG 0x007C++0x4
        LINE.LONG 0x00 "TXBCRR1,TX Buffer Cancellation Request Register 1"
            BITFLD.LONG 0x00 0.--31. "CR1    ,CR1"
    GROUP.LONG 0x0080++0x4
        LINE.LONG 0x00 "TXBTOR0,TX Buffer Transmission Occurred Register 0"
            BITFLD.LONG 0x00 0.--31. "TO0    ,TO0"
    GROUP.LONG 0x0084++0x4
        LINE.LONG 0x00 "TXBTOR1,TX Buffer Transmission Occurred Register 1"
            BITFLD.LONG 0x00 0.--31. "TO1    ,TO1"
    GROUP.LONG 0x0088++0x4
        LINE.LONG 0x00 "TXBCFR0,TX Buffer Cancellation Finished Register 0"
            BITFLD.LONG 0x00 0.--31. "CF0    ,CF0"
    GROUP.LONG 0x008C++0x4
        LINE.LONG 0x00 "TXBCFR1,TX Buffer Cancellation Finished Register 1"
            BITFLD.LONG 0x00 0.--31. "CF1    ,CF1"
    GROUP.LONG 0x0090++0x4
        LINE.LONG 0x00 "TXBTIER0,TX Buffer Transmission Interrupt Enable Register 0"
            BITFLD.LONG 0x00 0.--31. "TIE0    ,TIE0"
    GROUP.LONG 0x0094++0x4
        LINE.LONG 0x00 "TXBTIER1,TX Buffer Transmission Interrupt Enable Register 1"
            BITFLD.LONG 0x00 0.--31. "TIE1    ,TIE1"
    GROUP.LONG 0x0098++0x4
        LINE.LONG 0x00 "TXBCIER0,TX Buffer Cancellation Finished Interrupt Enable Register 0"
            BITFLD.LONG 0x00 0.--31. "CFIE0    ,CFIE0"
    GROUP.LONG 0x009C++0x4
        LINE.LONG 0x00 "TXBCIER1,TX Buffer Cancellation Finished Interrupt Enable Register 1"
            BITFLD.LONG 0x00 0.--31. "CFIE1    ,CFIE1"
    GROUP.LONG 0x00A0++0x4
        LINE.LONG 0x00 "TXFCFGR,TX FIFO Configuration Register"
            BITFLD.LONG 0x00 24.--31. "TXFWM    ,TXFWM"
            BITFLD.LONG 0x00 16.--23. "TXFSZ    ,TXFSZ"
            BITFLD.LONG 0x00 1.--15. "TXFCFGR_RSVD    ,TXFCFGR_RSVD"
            BITFLD.LONG 0x00 0. "TXFOPM    ,TXFOPM" "0,1"
            NEWLINE
    GROUP.LONG 0x00A4++0x4
        LINE.LONG 0x00 "TXFSTAR,TX FIFO Status Register"
            BITFLD.LONG 0x00 24.--31. "TXFPI    ,TXFPI"
            BITFLD.LONG 0x00 16.--23. "TXFGI    ,TXFGI"
            BITFLD.LONG 0x00 8.--15. "TXFLV    ,TXFLV"
            BITFLD.LONG 0x00 7. "TXFML    ,TXFML" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "TXFF    ,TXFF" "0,1"
            BITFLD.LONG 0x00 5. "TXFE    ,TXFE" "0,1"
            BITFLD.LONG 0x00 1.--4. "TXFSTAR_RSVD    ,TXFSTAR_RSVD"
            BITFLD.LONG 0x00 0. "TXFACK    ,TXFACK" "0,1"
            NEWLINE
    GROUP.LONG 0x00A8++0x4
        LINE.LONG 0x00 "TXEFCFGR,TX Event FIFO Configuration Register"
            BITFLD.LONG 0x00 24.--31. "TEFWM    ,TEFWM"
            BITFLD.LONG 0x00 16.--23. "TEFSZ    ,TEFSZ"
            BITFLD.LONG 0x00 1.--15. "TXEFCFGR_RSVD    ,TXEFCFGR_RSVD"
            BITFLD.LONG 0x00 0. "TEFOPM    ,TEFOPM" "0,1"
            NEWLINE
    GROUP.LONG 0x00AC++0x4
        LINE.LONG 0x00 "TXEFSTAR,TX Event FIFO Status Register"
            BITFLD.LONG 0x00 24.--31. "TEFPI    ,TEFPI"
            BITFLD.LONG 0x00 16.--23. "TEFGI    ,TEFGI"
            BITFLD.LONG 0x00 8.--15. "TEFLV    ,TEFLV"
            BITFLD.LONG 0x00 7. "TEFML    ,TEFML" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "TEFF    ,TEFF" "0,1"
            BITFLD.LONG 0x00 5. "TEFE    ,TEFE" "0,1"
            BITFLD.LONG 0x00 1.--4. "TXEFSTAR_RSVD    ,TXEFSTAR_RSVD"
            BITFLD.LONG 0x00 0. "TEFACK    ,TEFACK" "0,1"
            NEWLINE
    GROUP.LONG 0x00B0++0x4
        LINE.LONG 0x00 "RXFELMR0,RX FIFO Element Register 0"
            BITFLD.LONG 0x00 0.--31. "HEAD0    ,HEAD0"
    GROUP.LONG 0x00B4++0x4
        LINE.LONG 0x00 "RXFELMR1,RX FIFO Element Register 1"
            BITFLD.LONG 0x00 0.--31. "HEAD1    ,HEAD1"
    GROUP.LONG 0x00B8++0x4
        LINE.LONG 0x00 "RXFELMR2,RX FIFO Element Register 2"
            BITFLD.LONG 0x00 0.--31. "DATA0    ,DATA0"
    GROUP.LONG 0x00BC++0x4
        LINE.LONG 0x00 "RXFELMR3,RX FIFO Element Register 3"
            BITFLD.LONG 0x00 0.--31. "DATA1    ,DATA1"
    GROUP.LONG 0x00C0++0x4
        LINE.LONG 0x00 "RXFELMR4,RX FIFO Element Register 4"
            BITFLD.LONG 0x00 0.--31. "DATA2    ,DATA2"
    GROUP.LONG 0x00C4++0x4
        LINE.LONG 0x00 "RXFELMR5,RX FIFO Element Register 5"
            BITFLD.LONG 0x00 0.--31. "DATA3    ,DATA3"
    GROUP.LONG 0x00C8++0x4
        LINE.LONG 0x00 "RXFELMR6,RX FIFO Element Register 6"
            BITFLD.LONG 0x00 0.--31. "DATA4    ,DATA4"
    GROUP.LONG 0x00CC++0x4
        LINE.LONG 0x00 "RXFELMR7,RX FIFO Element Register 7"
            BITFLD.LONG 0x00 0.--31. "DATA5    ,DATA5"
    GROUP.LONG 0x00D0++0x4
        LINE.LONG 0x00 "RXFELMR8,RX FIFO Element Register 8"
            BITFLD.LONG 0x00 0.--31. "DATA6    ,DATA6"
    GROUP.LONG 0x00D4++0x4
        LINE.LONG 0x00 "RXFELMR9,RX FIFO Element Register 9"
            BITFLD.LONG 0x00 0.--31. "DATA7    ,DATA7"
    GROUP.LONG 0x00D8++0x4
        LINE.LONG 0x00 "RXFELMR10,RX FIFO Element Register 10"
            BITFLD.LONG 0x00 0.--31. "DATA8    ,DATA8"
    GROUP.LONG 0x00DC++0x4
        LINE.LONG 0x00 "RXFELMR11,RX FIFO Element Register 11"
            BITFLD.LONG 0x00 0.--31. "DATA9    ,DATA9"
    GROUP.LONG 0x00E0++0x4
        LINE.LONG 0x00 "RXFELMR12,RX FIFO Element Register 12"
            BITFLD.LONG 0x00 0.--31. "DATA10    ,DATA10"
    GROUP.LONG 0x00E4++0x4
        LINE.LONG 0x00 "RXFELMR13,RX FIFO Element Register 13"
            BITFLD.LONG 0x00 0.--31. "DATA11    ,DATA11"
    GROUP.LONG 0x00E8++0x4
        LINE.LONG 0x00 "RXFELMR14,RX FIFO Element Register 14"
            BITFLD.LONG 0x00 0.--31. "DATA12    ,DATA12"
    GROUP.LONG 0x00EC++0x4
        LINE.LONG 0x00 "RXFELMR15,RX FIFO Element Register 15"
            BITFLD.LONG 0x00 0.--31. "DATA13    ,DATA13"
    GROUP.LONG 0x00F0++0x4
        LINE.LONG 0x00 "RXFELMR16,RX FIFO Element Register 16"
            BITFLD.LONG 0x00 0.--31. "DATA14    ,DATA14"
    GROUP.LONG 0x00F4++0x4
        LINE.LONG 0x00 "RXFELMR17,RX FIFO Element Register 17"
            BITFLD.LONG 0x00 0.--31. "DATA15    ,DATA15"
    GROUP.LONG 0x00F8++0x4
        LINE.LONG 0x00 "TXFELMR0,TX FIFO Element Register 0"
            BITFLD.LONG 0x00 0.--31. "HEAD0    ,HEAD0"
    GROUP.LONG 0x00FC++0x4
        LINE.LONG 0x00 "TXFELMR1,TX FIFO Element Register 1"
            BITFLD.LONG 0x00 0.--31. "HEAD1    ,HEAD1"
    GROUP.LONG 0x0100++0x4
        LINE.LONG 0x00 "TXFELMR2,TX FIFO Element Register 2"
            BITFLD.LONG 0x00 0.--31. "DATA0    ,DATA0"
    GROUP.LONG 0x0104++0x4
        LINE.LONG 0x00 "TXFELMR3,TX FIFO Element Register 3"
            BITFLD.LONG 0x00 0.--31. "DATA1    ,DATA1"
    GROUP.LONG 0x0108++0x4
        LINE.LONG 0x00 "TXFELMR4,TX FIFO Element Register 4"
            BITFLD.LONG 0x00 0.--31. "DATA2    ,DATA2"
    GROUP.LONG 0x010C++0x4
        LINE.LONG 0x00 "TXFELMR5,TX FIFO Element Register 5"
            BITFLD.LONG 0x00 0.--31. "DATA3    ,DATA3"
    GROUP.LONG 0x0110++0x4
        LINE.LONG 0x00 "TXFELMR6,TX FIFO Element Register 6"
            BITFLD.LONG 0x00 0.--31. "DATA4    ,DATA4"
    GROUP.LONG 0x0114++0x4
        LINE.LONG 0x00 "TXFELMR7,TX FIFO Element Register 7"
            BITFLD.LONG 0x00 0.--31. "DATA5    ,DATA5"
    GROUP.LONG 0x0118++0x4
        LINE.LONG 0x00 "TXFELMR8,TX FIFO Element Register 8"
            BITFLD.LONG 0x00 0.--31. "DATA6    ,DATA6"
    GROUP.LONG 0x011C++0x4
        LINE.LONG 0x00 "TXFELMR9,TX FIFO Element Register 9"
            BITFLD.LONG 0x00 0.--31. "DATA7    ,DATA7"
    GROUP.LONG 0x0120++0x4
        LINE.LONG 0x00 "TXFELMR10,TX FIFO Element Register 10"
            BITFLD.LONG 0x00 0.--31. "DATA8    ,DATA8"
    GROUP.LONG 0x0124++0x4
        LINE.LONG 0x00 "TXFELMR11,TX FIFO Element Register 11"
            BITFLD.LONG 0x00 0.--31. "DATA9    ,DATA9"
    GROUP.LONG 0x0128++0x4
        LINE.LONG 0x00 "TXFELMR12,TX FIFO Element Register 12"
            BITFLD.LONG 0x00 0.--31. "DATA10    ,DATA10"
    GROUP.LONG 0x012C++0x4
        LINE.LONG 0x00 "TXFELMR13,TX FIFO Element Register 13"
            BITFLD.LONG 0x00 0.--31. "DATA11    ,DATA11"
    GROUP.LONG 0x0130++0x4
        LINE.LONG 0x00 "TXFELMR14,TX FIFO Element Register 14"
            BITFLD.LONG 0x00 0.--31. "DATA12    ,DATA12"
    GROUP.LONG 0x0134++0x4
        LINE.LONG 0x00 "TXFELMR15,TX FIFO Element Register 15"
            BITFLD.LONG 0x00 0.--31. "DATA13    ,DATA13"
    GROUP.LONG 0x0138++0x4
        LINE.LONG 0x00 "TXFELMR16,TX FIFO Element Register 16"
            BITFLD.LONG 0x00 0.--31. "DATA14    ,DATA14"
    GROUP.LONG 0x013C++0x4
        LINE.LONG 0x00 "TXFELMR17,TX FIFO Element Register 17"
            BITFLD.LONG 0x00 0.--31. "DATA15    ,DATA15"
    GROUP.LONG 0x0140++0x4
        LINE.LONG 0x00 "TXEFELMR0,TX Event FIFO Element Register 0"
            BITFLD.LONG 0x00 0.--31. "HEAD0    ,HEAD0"
    GROUP.LONG 0x0144++0x03
        LINE.LONG 0x00 "TXEFELMR1,TX Event FIFO Element Register 1"
            BITFLD.LONG 0x00 0.--31. "HEAD1    ,HEAD1"
TREE.END
TREE.END

TREE "SPI MODULE"
TREE "QSPI MODULE"
    BASE ad:0xb90000
    GROUP.LONG 0x0++0x03
        LINE.LONG 0x00 "QCTRLR0,Control Register 0"
            BITFLD.LONG 0x00 24. "SSTE    ,SSTE" "0,1"
            BITFLD.LONG 0x00 23. "RSVD_CTRLR0_23    ,RSVD_CTRLR0_23" "0,1"
            BITFLD.LONG 0x00 21.--22. "SPI_FRF    ,SPI_FRF" "0,1,2,3"
            BITFLD.LONG 0x00 16.--20. "DFS_32    ,DFS_32"
            NEWLINE
            BITFLD.LONG 0x00 12.--15. "CFS    ,CFS"
            BITFLD.LONG 0x00 11. "SRL    ,SRL" "0,1"
            BITFLD.LONG 0x00 10. "SLV_OE    ,SLV_OE" "0,1"
            BITFLD.LONG 0x00 8.--9. "TMOD    ,TMOD" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 7. "SCPOL    ,SCPOL" "0,1"
            BITFLD.LONG 0x00 6. "SCPH    ,SCPH" "0,1"
            BITFLD.LONG 0x00 4.--5. "FRF    ,FRF" "0,1,2,3"
            BITFLD.LONG 0x00 0.--3. "RSVD_CTRLR0_3_0    ,RSVD_CTRLR0_3_0"
            NEWLINE
    GROUP.LONG 0x4++0x03
        LINE.LONG 0x00 "QCTRLR1,Control Register 1"
            BITFLD.LONG 0x00 0.--15. "NDF    ,NDF"
    GROUP.LONG 0x8++0x03
        LINE.LONG 0x00 "QSSIENR,SSI Enable Register"
            BITFLD.LONG 0x00 0. "SSI_EN    ,SSI_EN" "0,1"
    GROUP.LONG 0xC++0x03
        LINE.LONG 0x00 "QMWCR,Microwire Control Register"
            BITFLD.LONG 0x00 2. "MHS    ,MHS" "0,1"
            BITFLD.LONG 0x00 1. "MDD    ,MDD" "0,1"
            BITFLD.LONG 0x00 0. "MWMOD    ,MWMOD" "0,1"
    GROUP.LONG 0x10++0x03
        LINE.LONG 0x00 "QSER,Slave Enable Register"
            BITFLD.LONG 0x00 0. "SER    ,SER" "0,1"
    GROUP.LONG 0x14++0x03
        LINE.LONG 0x00 "QBAUDR,Baud Rate Select"
            BITFLD.LONG 0x00 0.--15. "SCKDV    ,SCKDV"
    GROUP.LONG 0x18++0x03
        LINE.LONG 0x00 "QTXFTLR,Transmit FIFO Threshold Level"
            BITFLD.LONG 0x00 0.--4. "TFT    ,TFT"
    GROUP.LONG 0x1c++0x03
        LINE.LONG 0x00 "QRXFTLR,Receive FIFO Threshold Level"
            BITFLD.LONG 0x00 0.--4. "RFT    ,RFT"
    GROUP.LONG 0x20++0x03
        LINE.LONG 0x00 "QTXFLR,Transmit FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "TXTFL    ,TXTFL"
    GROUP.LONG 0x24++0x03
        LINE.LONG 0x00 "QRXFLR,Receive FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "RXTFL    ,RXTFL"
    GROUP.LONG 0x28++0x03
        LINE.LONG 0x00 "QSR,Status Register"
            BITFLD.LONG 0x00 6. "DCOL    ,DCOL" "0,1"
            BITFLD.LONG 0x00 5. "RSVD_SR_5     ,RSVD_SR_5 " "0,1"
            BITFLD.LONG 0x00 4. "RFF    ,RFF" "0,1"
            BITFLD.LONG 0x00 3. "RFNE    ,RFNE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 2. "TFE    ,TFE" "0,1"
            BITFLD.LONG 0x00 1. "TFNF    ,TFNF" "0,1"
            BITFLD.LONG 0x00 0. "BUSY    ,BUSY" "0,1"
    GROUP.LONG 0x2c++0x03
        LINE.LONG 0x00 "QIMR,Interrupt Mask Register"
            BITFLD.LONG 0x00 5. "MSTIM    ,MSTIM" "0,1"
            BITFLD.LONG 0x00 4. "RXFIM    ,RXFIM" "0,1"
            BITFLD.LONG 0x00 3. "RXOIM    ,RXOIM" "0,1"
            BITFLD.LONG 0x00 2. "RXUIM    ,RXUIM" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIM    ,TXOIM" "0,1"
            BITFLD.LONG 0x00 0. "TXEIM    ,TXEIM" "0,1"
    GROUP.LONG 0x30++0x03
        LINE.LONG 0x00 "QISR,Interrupt Status Register"
            BITFLD.LONG 0x00 5. "MSTIS    ,MSTIS" "0,1"
            BITFLD.LONG 0x00 4. "RXFIS    ,RXFIS" "0,1"
            BITFLD.LONG 0x00 3. "RXOIS    ,RXOIS" "0,1"
            BITFLD.LONG 0x00 2. "RXUIS    ,RXUIS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIS    ,TXOIS" "0,1"
            BITFLD.LONG 0x00 0. "TXEIS    ,TXEIS" "0,1"
    GROUP.LONG 0x34++0x03
        LINE.LONG 0x00 "QRISR,Raw Interrupt Status Register"
            BITFLD.LONG 0x00 5. "MSTIR    ,MSTIR" "0,1"
            BITFLD.LONG 0x00 4. "RXFIR    ,RXFIR" "0,1"
            BITFLD.LONG 0x00 3. "RXOIR    ,RXOIR" "0,1"
            BITFLD.LONG 0x00 2. "RXUIR    ,RXUIR" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIR    ,TXOIR" "0,1"
            BITFLD.LONG 0x00 0. "TXEIR    ,TXEIR" "0,1"
    GROUP.LONG 0x38++0x03
        LINE.LONG 0x00 "QTXOICR,Transmit FIFO Overflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "TXOICR    ,TXOICR" "0,1"
    GROUP.LONG 0x3c++0x03
        LINE.LONG 0x00 "QRXOICR,Receive FIFO Overflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "RXOICR    ,RXOICR" "0,1"
    GROUP.LONG 0x40++0x03
        LINE.LONG 0x00 "QRXUICR,Receive FIFO Underflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "RXUICR    ,RXUICR" "0,1"
    GROUP.LONG 0x44++0x03
        LINE.LONG 0x00 "QMSTICR,Multi-Master Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "MSTICR    ,MSTICR" "0,1"
    GROUP.LONG 0x48++0x03
        LINE.LONG 0x00 "QICR,Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "ICR    ,ICR" "0,1"
    GROUP.LONG 0x4c++0x03
        LINE.LONG 0x00 "QDMACR,DMA Control Register"
            BITFLD.LONG 0x00 1. "TDMAE    ,TDMAE" "0,1"
            BITFLD.LONG 0x00 0. "RDMAE    ,RDMAE" "0,1"
    GROUP.LONG 0x50++0x03
        LINE.LONG 0x00 "QDMATDLR,DMA Transmit Data Level"
            BITFLD.LONG 0x00 0.--4. "DMATDL    ,DMATDL"
    GROUP.LONG 0x54++0x03
        LINE.LONG 0x00 "QDMARDLR,DMA Receive Data Level"
            BITFLD.LONG 0x00 0.--4. "DMARDL    ,DMARDL"
    GROUP.LONG 0x58++0x03
        LINE.LONG 0x00 "QIDR,Identification Register"
            HEXMASK.LONG 0x00 0.--31. "IDCODE    ,IDCODE"
    GROUP.LONG 0x5c++0x03
        LINE.LONG 0x00 "QSSI_VERSION_ID,coreKit version ID Register"
            HEXMASK.LONG 0x00 0.--31. "SSI_COMP_VERSION    ,SSI_COMP_VERSION"
    GROUP.LONG 0x60++0x90
        LINE.LONG 0x00 "QDRx (for x = 0; x <= 31),Data Register x"
            BITFLD.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0xf0++0x03
        LINE.LONG 0x00 "QRX_SAMPLE_DLY,RX Sample Delay Register"
            BITFLD.LONG 0x00 0.--4. "RSD    ,RSD"
    GROUP.LONG 0xf4++0x03
        LINE.LONG 0x00 "QSPI_CTRLR0,SPI Control Register"
            BITFLD.LONG 0x00 18. "SPI_RXD_EN    ,SPI_RXD_EN" "0,1"
            BITFLD.LONG 0x00 17. "INST_DDR_EN    ,INST_DDR_EN" "0,1"
            BITFLD.LONG 0x00 16. "SPI_DDR_EN    ,SPI_DDR_EN" "0,1"
            BITFLD.LONG 0x00 11.--15. "WAIT_CYCLES    ,WAIT_CYCLES"
            NEWLINE
            BITFLD.LONG 0x00 10. "RSVD_SPI_CTRLR0_10    ,RSVD_SPI_CTRLR0_10" "0,1"
            BITFLD.LONG 0x00 8.--9. "INST_L    ,INST_L" "0,1,2,3"
            BITFLD.LONG 0x00 6.--7. "RSVD_SPI_CTRLR0_6_7    ,RSVD_SPI_CTRLR0_6_7" "0,1,2,3"
            BITFLD.LONG 0x00 2.--5. "ADDR_L    ,ADDR_L"
            NEWLINE
            BITFLD.LONG 0x00 0.--1. "TRANS_TYPE    ,TRANS_TYPE" "0,1,2,3"
    GROUP.LONG 0xf8++0x03
        LINE.LONG 0x00 "QSPI_TXD_DRIVE_EDGE,Transmit Drive Edge Register"
            BITFLD.LONG 0x00 8.--31. "RSVD_TXD_DRIVE_EDGE    ,RSVD_TXD_DRIVE_EDGE"
            BITFLD.LONG 0x00 0.--7. "TDE    ,TDE"
    GROUP.LONG 0xfc++0x03
        LINE.LONG 0x00 "QRSVD,RSVD - Reserved address location"
            BITFLD.LONG 0x00 0.--31. "RSVD    ,RSVD"
TREE.END


TREE "SPI_M MODULE"
    BASE ad:0xb60000
    GROUP.LONG 0x0++0x3
        LINE.LONG 0x00 "MCTRLR0,Control Register 0"
            BITFLD.LONG 0x00 24. "SSTE    ,SSTE" "0,1"
            BITFLD.LONG 0x00 23. "RSVD_CTRLR0_23    ,RSVD_CTRLR0_23" "0,1"
            BITFLD.LONG 0x00 21.--22. "RSVD_SPI_FRF    ,RSVD_SPI_FRF" "0,1,2,3"
            BITFLD.LONG 0x00 16.--20. "DFS_32    ,DFS_32"
            NEWLINE
            BITFLD.LONG 0x00 12.--15. "CFS    ,CFS"
            BITFLD.LONG 0x00 11. "SRL    ,SRL" "0,1"
            BITFLD.LONG 0x00 10. "SLV_OE    ,SLV_OE" "0,1"
            BITFLD.LONG 0x00 8.--9. "TMOD    ,TMOD" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 7. "SCPOL    ,SCPOL" "0,1"
            BITFLD.LONG 0x00 6. "SCPH    ,SCPH" "0,1"
            BITFLD.LONG 0x00 4.--5. "FRF    ,FRF" "0,1,2,3"
            BITFLD.LONG 0x00 0.--3. "RSVD_CTRLR0_3_0    ,RSVD_CTRLR0_3_0"
            NEWLINE
    GROUP.LONG 0x8++0x03
        LINE.LONG 0x00 "MSSIENR,SSI Enable Register"
            BITFLD.LONG 0x00 0. "SSI_EN    ,SSI_EN" "0,1"
    GROUP.LONG 0xc++0x03
        LINE.LONG 0x00 "MMWCR,Microwire Control Register"
            BITFLD.LONG 0x00 2. "MHS    ,MHS" "0,1"
            BITFLD.LONG 0x00 1. "MDD    ,MDD" "0,1"
            BITFLD.LONG 0x00 0. "MWMOD    ,MWMOD" "0,1"
    GROUP.LONG 0x10++0x03
        LINE.LONG 0x00 "MSER,Slave Enable Register"
            BITFLD.LONG 0x00 3.--31. "RSVD_SER    ,RSVD_SER"
            BITFLD.LONG 0x00 0.--2. "SER    ,SER"
    GROUP.LONG 0x14++0x03
        LINE.LONG 0x00 "MBAUDR,Baud Rate Select"
            BITFLD.LONG 0x00 0.--15. "SCKDV    ,SCKDV"
    GROUP.LONG 0x18++0x03
        LINE.LONG 0x00 "MTXFTLR,Transmit FIFO Threshold Level"
            BITFLD.LONG 0x00 0.--4. "TFT    ,TFT"
    GROUP.LONG 0x1c++0x03
        LINE.LONG 0x00 "MRXFTLR,Receive FIFO Threshold Level"
            BITFLD.LONG 0x00 0.--4. "RFT    ,RFT"
    GROUP.LONG 0x20++0x03
        LINE.LONG 0x00 "MTXFLR,Transmit FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "TXTFL    ,TXTFL"
    GROUP.LONG 0x24++0x03
        LINE.LONG 0x00 "MRXFLR,Receive FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "RXTFL    ,RXTFL"
    GROUP.LONG 0x28++0x03
        LINE.LONG 0x00 "MSR,Status Register"
            BITFLD.LONG 0x00 6. "DCOL    ,DCOL" "0,1"
            BITFLD.LONG 0x00 5. "RSVD_SR_5     ,RSVD_SR_5 " "0,1"
            BITFLD.LONG 0x00 4. "RFF    ,RFF" "0,1"
            BITFLD.LONG 0x00 3. "RFNE    ,RFNE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 2. "TFE    ,TFE" "0,1"
            BITFLD.LONG 0x00 1. "TFNF    ,TFNF" "0,1"
            BITFLD.LONG 0x00 0. "BUSY    ,BUSY" "0,1"
    GROUP.LONG 0x2c++0x03
        LINE.LONG 0x00 "MIMR,Interrupt Mask Register"
            BITFLD.LONG 0x00 5. "MSTIM    ,MSTIM" "0,1"
            BITFLD.LONG 0x00 4. "RXFIM    ,RXFIM" "0,1"
            BITFLD.LONG 0x00 3. "RXOIM    ,RXOIM" "0,1"
            BITFLD.LONG 0x00 2. "RXUIM    ,RXUIM" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIM    ,TXOIM" "0,1"
            BITFLD.LONG 0x00 0. "TXEIM    ,TXEIM" "0,1"
    GROUP.LONG 0x30++0x03
        LINE.LONG 0x00 "MISR,Interrupt Status Register"
            BITFLD.LONG 0x00 5. "MSTIS    ,MSTIS" "0,1"
            BITFLD.LONG 0x00 4. "RXFIS    ,RXFIS" "0,1"
            BITFLD.LONG 0x00 3. "RXOIS    ,RXOIS" "0,1"
            BITFLD.LONG 0x00 2. "RXUIS    ,RXUIS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIS    ,TXOIS" "0,1"
            BITFLD.LONG 0x00 0. "TXEIS    ,TXEIS" "0,1"
    GROUP.LONG 0x34++0x03
        LINE.LONG 0x00 "MRISR,Raw Interrupt Status Register"
            BITFLD.LONG 0x00 5. "MSTIR    ,MSTIR" "0,1"
            BITFLD.LONG 0x00 4. "RXFIR    ,RXFIR" "0,1"
            BITFLD.LONG 0x00 3. "RXOIR    ,RXOIR" "0,1"
            BITFLD.LONG 0x00 2. "RXUIR    ,RXUIR" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIR    ,TXOIR" "0,1"
            BITFLD.LONG 0x00 0. "TXEIR    ,TXEIR" "0,1"
    GROUP.LONG 0x38++0x03
        LINE.LONG 0x00 "MTXOICR,Transmit FIFO Overflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "TXOICR    ,TXOICR" "0,1"
    GROUP.LONG 0x3c++0x03
        LINE.LONG 0x00 "MRXOICR,Receive FIFO Overflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "RXOICR    ,RXOICR" "0,1"
    GROUP.LONG 0x40++0x03
        LINE.LONG 0x00 "MRXUICR,Receive FIFO Underflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "RXUICR    ,RXUICR" "0,1"
    GROUP.LONG 0x44++0x03
        LINE.LONG 0x00 "MMSTICR,Multi-Master Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "MSTICR    ,MSTICR" "0,1"
    GROUP.LONG 0x48++0x03
        LINE.LONG 0x00 "MICR,Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "ICR    ,ICR" "0,1"
    GROUP.LONG 0x4c++0x03
        LINE.LONG 0x00 "MDMACR,DMA Control Register"
            BITFLD.LONG 0x00 1. "TDMAE    ,TDMAE" "0,1"
            BITFLD.LONG 0x00 0. "RDMAE    ,RDMAE" "0,1"
    GROUP.LONG 0x50++0x03
        LINE.LONG 0x00 "MDMATDLR,DMA Transmit Data Level"
            BITFLD.LONG 0x00 0.--4. "DMATDL    ,DMATDL"
    GROUP.LONG 0x54++0x03
        LINE.LONG 0x00 "MDMARDLR,DMA Receive Data Level"
            BITFLD.LONG 0x00 0.--4. "DMARDL    ,DMARDL"
    GROUP.LONG 0x58++0x03
        LINE.LONG 0x00 "MIDR,Identification Register"
            HEXMASK.LONG 0x00 0.--31. "IDCODE    ,IDCODE"
    GROUP.LONG 0x5c++0x03
        LINE.LONG 0x00 "MSSI_VERSION_ID,coreKit version ID Register"
            HEXMASK.LONG 0x00 0.--31. "SSI_COMP_VERSION    ,SSI_COMP_VERSION"
    GROUP.LONG 0x60++0x90
        LINE.LONG 0x00 "MDRx (for x = 0; x <= 31),Data Register x"
            BITFLD.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0xf0++0xc
        LINE.LONG 0x00 "MRX_SAMPLE_DLY,RX Sample Delay Register"
            BITFLD.LONG 0x00 0.--4. "RSD    ,RSD"
    GROUP.LONG 0xfc++0x03
        LINE.LONG 0x00 "MRSVD,RSVD - Reserved address location"
            BITFLD.LONG 0x00 0.--31. "RSVD    ,RSVD"
TREE.END


TREE "SPI_S MODULE"
    BASE ad:0xb80000
    GROUP.LONG 0x0++0x3
        LINE.LONG 0x00 "SCTRLR0,Control Register 0"
            BITFLD.LONG 0x00 24. "SSTE    ,SSTE" "0,1"
            BITFLD.LONG 0x00 23. "RSVD_CTRLR0_23    ,RSVD_CTRLR0_23" "0,1"
            BITFLD.LONG 0x00 21.--22. "RSVD_SPI_FRF    ,RSVD_SPI_FRF" "0,1,2,3"
            BITFLD.LONG 0x00 16.--20. "DFS_32    ,DFS_32"
            NEWLINE
            BITFLD.LONG 0x00 12.--15. "CFS    ,CFS"
            BITFLD.LONG 0x00 11. "SRL    ,SRL" "0,1"
            BITFLD.LONG 0x00 10. "SLV_OE    ,SLV_OE" "0,1"
            BITFLD.LONG 0x00 8.--9. "TMOD    ,TMOD" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 7. "SCPOL    ,SCPOL" "0,1"
            BITFLD.LONG 0x00 6. "SCPH    ,SCPH" "0,1"
            BITFLD.LONG 0x00 4.--5. "FRF    ,FRF" "0,1,2,3"
            BITFLD.LONG 0x00 0.--3. "RSVD_CTRLR0_3_0    ,RSVD_CTRLR0_3_0"
            NEWLINE
    GROUP.LONG 0x8++0x3
        LINE.LONG 0x00 "SSSIENR,SSI Enable Register"
            BITFLD.LONG 0x00 0. "SSI_EN    ,SSI_EN" "0,1"
    GROUP.LONG 0x18++0x03
        LINE.LONG 0x00 "STXFTLR,Transmit FIFO Threshold Level"
            BITFLD.LONG 0x00 0.--4. "TFT    ,TFT"
    GROUP.LONG 0x1c++0x03
        LINE.LONG 0x00 "SRXFTLR,Receive FIFO Threshold Level"
            BITFLD.LONG 0x00 0.--4. "RFT    ,RFT"
    GROUP.LONG 0x20++0x03
        LINE.LONG 0x00 "STXFLR,Transmit FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "TXTFL    ,TXTFL"
    GROUP.LONG 0x24++0x03
        LINE.LONG 0x00 "SRXFLR,Receive FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "RXTFL    ,RXTFL"
    GROUP.LONG 0x28++0x03
        LINE.LONG 0x00 "SSR,Status Register"
            BITFLD.LONG 0x00 5. "TXE    ,TXE" "0,1"
            BITFLD.LONG 0x00 4. "RFF    ,RFF" "0,1"
            BITFLD.LONG 0x00 3. "RFNE    ,RFNE" "0,1"
            BITFLD.LONG 0x00 2. "TFE    ,TFE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TFNF    ,TFNF" "0,1"
            BITFLD.LONG 0x00 0. "BUSY    ,BUSY" "0,1"
    GROUP.LONG 0x2c++0x03
        LINE.LONG 0x00 "SIMR,Interrupt Mask Register"
            BITFLD.LONG 0x00 4. "RXFIM    ,RXFIM" "0,1"
            BITFLD.LONG 0x00 3. "RXOIM    ,RXOIM" "0,1"
            BITFLD.LONG 0x00 2. "RXUIM    ,RXUIM" "0,1"
            BITFLD.LONG 0x00 1. "TXOIM    ,TXOIM" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0. "TXEIM    ,TXEIM" "0,1"
    GROUP.LONG 0x30++0x03
        LINE.LONG 0x00 "SISR,Interrupt Status Register"
            BITFLD.LONG 0x00 4. "RXFIS    ,RXFIS" "0,1"
            BITFLD.LONG 0x00 3. "RXOIS    ,RXOIS" "0,1"
            BITFLD.LONG 0x00 2. "RXUIS    ,RXUIS" "0,1"
            BITFLD.LONG 0x00 1. "TXOIS    ,TXOIS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0. "TXEIS    ,TXEIS" "0,1"
    GROUP.LONG 0x34++0x03
        LINE.LONG 0x00 "SRISR,Raw Interrupt Status Register"
            BITFLD.LONG 0x00 4. "RXFIR    ,RXFIR" "0,1"
            BITFLD.LONG 0x00 3. "RXOIR    ,RXOIR" "0,1"
            BITFLD.LONG 0x00 2. "RXUIR    ,RXUIR" "0,1"
            BITFLD.LONG 0x00 1. "TXOIR    ,TXOIR" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0. "TXEIR    ,TXEIR" "0,1"
    GROUP.LONG 0x38++0x03
        LINE.LONG 0x00 "STXOICR,Transmit FIFO Overflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "TXOICR    ,TXOICR" "0,1"
    GROUP.LONG 0x3c++0x03
        LINE.LONG 0x00 "SRXOICR,Receive FIFO Overflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "RXOICR    ,RXOICR" "0,1"
    GROUP.LONG 0x40++0x8
        LINE.LONG 0x00 "SRXUICR,Receive FIFO Underflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "RXUICR    ,RXUICR" "0,1"
    GROUP.LONG 0x48++0x03
        LINE.LONG 0x00 "SICR,Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "ICR    ,ICR" "0,1"
    GROUP.LONG 0x4c++0x03
        LINE.LONG 0x00 "SDMACR,DMA Control Register"
            BITFLD.LONG 0x00 1. "TDMAE    ,TDMAE" "0,1"
            BITFLD.LONG 0x00 0. "RDMAE    ,RDMAE" "0,1"
    GROUP.LONG 0x50++0x03
        LINE.LONG 0x00 "SDMATDLR,DMA Transmit Data Level"
            BITFLD.LONG 0x00 0.--4. "DMATDL    ,DMATDL"
    GROUP.LONG 0x54++0x03
        LINE.LONG 0x00 "SDMARDLR,DMA Receive Data Level"
            BITFLD.LONG 0x00 0.--4. "DMARDL    ,DMARDL"
    GROUP.LONG 0x58++0x03
        LINE.LONG 0x00 "SIDR,Identification Register"
            HEXMASK.LONG 0x00 0.--31. "IDCODE    ,IDCODE"
    GROUP.LONG 0x5c++0x03
        LINE.LONG 0x00 "SSSI_VERSION_ID,coreKit version ID Register"
            HEXMASK.LONG 0x00 0.--31. "SSI_COMP_VERSION    ,SSI_COMP_VERSION"
    GROUP.LONG 0x60++0x03
        LINE.LONG 0x00 "SDRx (for x = 0; x <= 31),Data Register x"
            BITFLD.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0xfc++0x03
        LINE.LONG 0x00 "SRSVD,RSVD - Reserved address location"
            BITFLD.LONG 0x00 0.--31. "RSVD    ,RSVD"
TREE.END
TREE.END

TREE "UART MODULE"
	TREE "UART0"
    BASE ad:0xb30000
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "RBR,Receive Buffer Register"
            BITFLD.LONG 0x00 0.--7. "RBR    ,RBR"
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "DLL,Divisor Latch (Low) Register"
            BITFLD.LONG 0x00 0.--7. "DLL    ,DLL"
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "THR,Transmit Holding Register"
            BITFLD.LONG 0x00 0.--7. "THR    ,THR"
    GROUP.LONG 0x4++0x04
        LINE.LONG 0x00 "DLH,Divisor Latch (High) Register"
            BITFLD.LONG 0x00 0.--7. "DLH    ,DLH"
    GROUP.LONG 0x4++0x4
        LINE.LONG 0x00 "IER,Interrupt Enable Register"
            BITFLD.LONG 0x00 7. "PTIME    ,PTIME" "0,1"
            BITFLD.LONG 0x00 4. "ELCOLR    ,ELCOLR" "0,1"
            BITFLD.LONG 0x00 3. "EDSSI    ,EDSSI" "0,1"
            BITFLD.LONG 0x00 2. "ELSI    ,ELSI" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "ETBEI    ,ETBEI" "0,1"
            BITFLD.LONG 0x00 0. "ERBFI    ,ERBFI" "0,1"
    GROUP.LONG 0x8++0x04
        LINE.LONG 0x00 "FCR,FIFO Control Register"
            BITFLD.LONG 0x00 6.--7. "RT    ,RT" "0,1,2,3"
            BITFLD.LONG 0x00 4.--5. "TET    ,TET" "0,1,2,3"
            BITFLD.LONG 0x00 3. "DMAM    ,DMAM" "0,1"
            BITFLD.LONG 0x00 2. "XFIFOR    ,XFIFOR" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "RFIFOR    ,RFIFOR" "0,1"
            BITFLD.LONG 0x00 0. "FIFOE    ,FIFOE" "0,1"
    GROUP.LONG 0x8++0x4
        LINE.LONG 0x00 "IIR,Interrupt Identification Register"
            BITFLD.LONG 0x00 6.--7. "FIFOSE    ,FIFOSE" "0,1,2,3"
            BITFLD.LONG 0x00 0.--3. "IID    ,IID"
    GROUP.LONG 0xc++0x4
        LINE.LONG 0x00 "LCR,Line Control Register"
            BITFLD.LONG 0x00 7. "DLAB    ,DLAB" "0,1"
            BITFLD.LONG 0x00 6. "BC    ,BC" "0,1"
            BITFLD.LONG 0x00 5. "SP    ,SP" "0,1"
            BITFLD.LONG 0x00 4. "EPS    ,EPS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "PEN    ,PEN" "0,1"
            BITFLD.LONG 0x00 2. "STOP    ,STOP" "0,1"
            BITFLD.LONG 0x00 0.--1. "DLS    ,DLS" "0,1,2,3"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "MCR,Modem Control Register"
            BITFLD.LONG 0x00 6. "SIRE    ,SIRE" "0,1"
            BITFLD.LONG 0x00 5. "AFCE    ,AFCE" "0,1"
            BITFLD.LONG 0x00 4. "LoopBack    ,LoopBack" "0,1"
            BITFLD.LONG 0x00 3. "OUT2    ,OUT2" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 2. "OUT1    ,OUT1" "0,1"
            BITFLD.LONG 0x00 1. "RTS    ,RTS" "0,1"
            BITFLD.LONG 0x00 0. "DTR    ,DTR" "0,1"
    GROUP.LONG 0x14++0x4
        LINE.LONG 0x00 "LSR,Line Status Register"
            BITFLD.LONG 0x00 7. "RFE    ,RFE" "0,1"
            BITFLD.LONG 0x00 6. "TEMT    ,TEMT" "0,1"
            BITFLD.LONG 0x00 5. "THRE    ,THRE" "0,1"
            BITFLD.LONG 0x00 4. "BI    ,BI" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "FE    ,FE" "0,1"
            BITFLD.LONG 0x00 2. "PE    ,PE" "0,1"
            BITFLD.LONG 0x00 1. "OE    ,OE" "0,1"
            BITFLD.LONG 0x00 0. "DR    ,DR" "0,1"
            NEWLINE
    GROUP.LONG 0x18++0x4
        LINE.LONG 0x00 "MSR,Modem Status Register"
            BITFLD.LONG 0x00 7. "DCD    ,DCD" "0,1"
            BITFLD.LONG 0x00 6. "RI    ,RI" "0,1"
            BITFLD.LONG 0x00 5. "DSR    ,DSR" "0,1"
            BITFLD.LONG 0x00 4. "CTS    ,CTS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "DDCD    ,DDCD" "0,1"
            BITFLD.LONG 0x00 2. "TERI    ,TERI" "0,1"
            BITFLD.LONG 0x00 1. "DDSR    ,DDSR" "0,1"
            BITFLD.LONG 0x00 0. "DCTS    ,DCTS" "0,1"
            NEWLINE
    GROUP.LONG 0x1c++0x4
        LINE.LONG 0x00 "SCR,Scratchpad Register"
            BITFLD.LONG 0x00 0.--7. "SCR    ,SCR"
    GROUP.LONG 0x20++0x4
        LINE.LONG 0x00 "LPDLL,Low Power Divisor Latch Low"
            BITFLD.LONG 0x00 0.--7. "LPDLL    ,LPDLL"
    GROUP.LONG 0x24++0x03
        LINE.LONG 0x00 "LPDLH,Low Power Divisor Latch High"
            BITFLD.LONG 0x00 0.--7. "LPDLH    ,LPDLH"
 
TREE "SRBRn"
	GROUP.LONG 0x30++0x03
        LINE.LONG 0x00 "SRBR0        ,Shadow Receive Buffer Register0"
            BITFLD.LONG 0x00 0.--7. "SRBR0    ,SRBR0"
    GROUP.LONG 0x34++0x03
        LINE.LONG 0x00 "SRBR1        ,Shadow Receive Buffer Register1"
            BITFLD.LONG 0x00 0.--7. "SRBR1    ,SRBR1"			
    GROUP.LONG 0x38++0x03
        LINE.LONG 0x00 "SRBR2        ,Shadow Receive Buffer Register2"
            BITFLD.LONG 0x00 0.--7. "SRBR2    ,SRBR2"			
    GROUP.LONG 0x3C++0x03
        LINE.LONG 0x00 "SRBR3        ,Shadow Receive Buffer Register3"
            BITFLD.LONG 0x00 0.--7. "SRBR3    ,SRBR3"
    GROUP.LONG 0x40++0x03
        LINE.LONG 0x00 "SRBR4        ,Shadow Receive Buffer Register4"
            BITFLD.LONG 0x00 0.--7. "SRBR4    ,SRBR4"
    GROUP.LONG 0x44++0x03
        LINE.LONG 0x00 "SRBR5        ,Shadow Receive Buffer Register5"
            BITFLD.LONG 0x00 0.--7. "SRBR5    ,SRBR5"
    GROUP.LONG 0x48++0x03
        LINE.LONG 0x00 "SRBR6        ,Shadow Receive Buffer Register6"
            BITFLD.LONG 0x00 0.--7. "SRBR6    ,SRBR6"
    GROUP.LONG 0x4C++0x03
        LINE.LONG 0x00 "SRBR7        ,Shadow Receive Buffer Register7"
            BITFLD.LONG 0x00 0.--7. "SRBR7    ,SRBR7"
    GROUP.LONG 0x50++0x03
        LINE.LONG 0x00 "SRBR8        ,Shadow Receive Buffer Register8"
            BITFLD.LONG 0x00 0.--7. "SRBR8    ,SRBR8"
    GROUP.LONG 0x54++0x03
        LINE.LONG 0x00 "SRBR9        ,Shadow Receive Buffer Register9"
            BITFLD.LONG 0x00 0.--7. "SRBR9    ,SRBR9"
    GROUP.LONG 0x58++0x03
        LINE.LONG 0x00 "SRBR10        ,Shadow Receive Buffer Register10"
            BITFLD.LONG 0x00 0.--7. "SRBR10    ,SRBR10"
    GROUP.LONG 0x5C++0x03
        LINE.LONG 0x00 "SRBR11        ,Shadow Receive Buffer Register11"
            BITFLD.LONG 0x00 0.--7. "SRBR11    ,SRBR11"
    GROUP.LONG 0x60++0x03
        LINE.LONG 0x00 "SRBR12        ,Shadow Receive Buffer Register12"
            BITFLD.LONG 0x00 0.--7. "SRBR12    ,SRBR12"
    GROUP.LONG 0x64++0x03
        LINE.LONG 0x00 "SRBR13        ,Shadow Receive Buffer Register13"
            BITFLD.LONG 0x00 0.--7. "SRBR13    ,SRBR13"
    GROUP.LONG 0x68++0x03
        LINE.LONG 0x00 "SRBR14        ,Shadow Receive Buffer Register14"
            BITFLD.LONG 0x00 0.--7. "SRBR14    ,SRBR14"
    GROUP.LONG 0x6C++0x03
        LINE.LONG 0x00 "SRBR15        ,Shadow Receive Buffer Register15"
            BITFLD.LONG 0x00 0.--7. "SRBR15    ,SRBR15"
TREE.END
TREE "STHRn"
	GROUP.LONG 0x30++0x03
        LINE.LONG 0x00 "STHR0        ,Shadow Transmit Holding Register0"
            BITFLD.LONG 0x00 0.--7. "STHR0    ,STHR0"
    GROUP.LONG 0x34++0x03
        LINE.LONG 0x00 "STHR1        ,Shadow Transmit Holding Register1"
            BITFLD.LONG 0x00 0.--7. "STHR1    ,STHR1"			
    GROUP.LONG 0x38++0x03
        LINE.LONG 0x00 "STHR2        ,Shadow Transmit Holding Register2"
            BITFLD.LONG 0x00 0.--7. "STHR2    ,STHR2"			
    GROUP.LONG 0x3C++0x03
        LINE.LONG 0x00 "STHR3        ,Shadow Transmit Holding Register3"
            BITFLD.LONG 0x00 0.--7. "STHR3    ,STHR3"
    GROUP.LONG 0x40++0x03
        LINE.LONG 0x00 "STHR4        ,Shadow Transmit Holding Register4"
            BITFLD.LONG 0x00 0.--7. "STHR4    ,STHR4"
    GROUP.LONG 0x44++0x03
        LINE.LONG 0x00 "STHR5        ,Shadow Transmit Holding Register5"
            BITFLD.LONG 0x00 0.--7. "STHR5    ,STHR5"
    GROUP.LONG 0x48++0x03
        LINE.LONG 0x00 "STHR6        ,Shadow Transmit Holding Register6"
            BITFLD.LONG 0x00 0.--7. "STHR6    ,STHR6"
    GROUP.LONG 0x4C++0x03
        LINE.LONG 0x00 "STHR7        ,Shadow Transmit Holding Register7"
            BITFLD.LONG 0x00 0.--7. "STHR7    ,STHR7"
    GROUP.LONG 0x50++0x03
        LINE.LONG 0x00 "STHR8        ,Shadow Transmit Holding Register8"
            BITFLD.LONG 0x00 0.--7. "STHR8    ,STHR8"
    GROUP.LONG 0x54++0x03
        LINE.LONG 0x00 "STHR9        ,Shadow Transmit Holding Register9"
            BITFLD.LONG 0x00 0.--7. "STHR9    ,STHR9"
    GROUP.LONG 0x58++0x03
        LINE.LONG 0x00 "STHR10        ,Shadow Transmit Holding Register10"
            BITFLD.LONG 0x00 0.--7. "STHR10    ,STHR10"
    GROUP.LONG 0x5C++0x03
        LINE.LONG 0x00 "STHR11        ,Shadow Transmit Holding Register11"
            BITFLD.LONG 0x00 0.--7. "STHR11    ,STHR11"
    GROUP.LONG 0x60++0x03
        LINE.LONG 0x00 "STHR12        ,Shadow Transmit Holding Register12"
            BITFLD.LONG 0x00 0.--7. "STHR12    ,STHR12"
    GROUP.LONG 0x64++0x03
        LINE.LONG 0x00 "STHR13        ,Shadow Transmit Holding Register13"
            BITFLD.LONG 0x00 0.--7. "STHR13    ,STHR13"
    GROUP.LONG 0x68++0x03
        LINE.LONG 0x00 "STHR14        ,Shadow Transmit Holding Register14"
            BITFLD.LONG 0x00 0.--7. "STHR14    ,STHR14"
    GROUP.LONG 0x6C++0x03
        LINE.LONG 0x00 "STHR15        ,Shadow Transmit Holding Register15"
            BITFLD.LONG 0x00 0.--7. "STHR15    ,STHR15"			
TREE.END
    GROUP.LONG 0x70++0x4
        LINE.LONG 0x00 "FAR,FIFO Access Register"
            BITFLD.LONG 0x00 0. "FAR    ,FAR" "0,1"
    GROUP.LONG 0x74++0x4
        LINE.LONG 0x00 "TFR,Transmit FIFO Read"
            BITFLD.LONG 0x00 0.--7. "TFR    ,TFR"
    GROUP.LONG 0x78++0x4
        LINE.LONG 0x00 "RFW,Receive FIFO Write"
            BITFLD.LONG 0x00 9. "RFFE    ,RFFE" "0,1"
            BITFLD.LONG 0x00 8. "RFPE    ,RFPE" "0,1"
            BITFLD.LONG 0x00 0.--7. "RFWD    ,RFWD"
    GROUP.LONG 0x7c++0x4
        LINE.LONG 0x00 "USR,UART Status register"
            BITFLD.LONG 0x00 4. "RFF    ,RFF" "0,1"
            BITFLD.LONG 0x00 3. "RFNE    ,RFNE" "0,1"
            BITFLD.LONG 0x00 2. "TFE    ,TFE" "0,1"
            BITFLD.LONG 0x00 1. "TFNF    ,TFNF" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0. "BUSY    ,BUSY" "0,1"
    GROUP.LONG 0x80++0x4
        LINE.LONG 0x00 "TFL,Transmit FIFO Level"
            BITFLD.LONG 0x00 0.--5. "TFL    ,TFL"
    GROUP.LONG 0x84++0x4
        LINE.LONG 0x00 "RFL,Receive FIFO Level"
            BITFLD.LONG 0x00 0.--5. "RFL    ,RFL"
    GROUP.LONG 0x88++0x4
        LINE.LONG 0x00 "SRR,Software Reset Register"
            BITFLD.LONG 0x00 2. "XFR    ,XFR" "0,1"
            BITFLD.LONG 0x00 1. "RFR    ,RFR" "0,1"
            BITFLD.LONG 0x00 0. "UR    ,UR" "0,1"
    GROUP.LONG 0x8c++0x4
        LINE.LONG 0x00 "SRTS,Shadow Request to Send"
            BITFLD.LONG 0x00 0. "SRTS    ,SRTS" "0,1"
    GROUP.LONG 0x90++0x4
        LINE.LONG 0x00 "SBCR,Shadow Break Control Register"
            BITFLD.LONG 0x00 0. "SBCB    ,SBCB" "0,1"
    GROUP.LONG 0x94++0x4
        LINE.LONG 0x00 "SDMAM,Shadow DMA Mode Register"
            BITFLD.LONG 0x00 0. "SDMAM    ,SDMAM" "0,1"
    GROUP.LONG 0x98++0x4
        LINE.LONG 0x00 "SFE,Shadow FIFO Enable Register"
            BITFLD.LONG 0x00 0. "SFE    ,SFE" "0,1"
    GROUP.LONG 0x9c++0x4
        LINE.LONG 0x00 "SRT,Shadow RCVR Trigger Register"
            BITFLD.LONG 0x00 0.--1. "SRT    ,SRT" "0,1,2,3"
    GROUP.LONG 0xa0++0x4
        LINE.LONG 0x00 "STET,Shadow TX Empty Trigger Register"
            BITFLD.LONG 0x00 0.--1. "STET    ,STET" "0,1,2,3"
    GROUP.LONG 0xa4++0x50
        LINE.LONG 0x00 "HTX,Halt TX Register"
            BITFLD.LONG 0x00 0. "HTX    ,HTX" "0,1"
    GROUP.LONG 0xf4++0x4
        LINE.LONG 0x00 "CPR,Component Parameter Register"
            BITFLD.LONG 0x00 16.--23. "FIFO_MODE    ,FIFO_MODE"
            BITFLD.LONG 0x00 13. "DMA_EXTRA    ,DMA_EXTRA" "0,1"
            BITFLD.LONG 0x00 12. "UART_ADD_ENCODED_PARAMS    ,UART_ADD_ENCODED_PARAMS" "0,1"
            BITFLD.LONG 0x00 11. "SHADOW    ,SHADOW" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 10. "FIFO_STAT    ,FIFO_STAT" "0,1"
            BITFLD.LONG 0x00 9. "FIFO_ACCESS    ,FIFO_ACCESS" "0,1"
            BITFLD.LONG 0x00 8. "ADDITIONAL_FEAT    ,ADDITIONAL_FEAT" "0,1"
            BITFLD.LONG 0x00 7. "SIR_LP_MODE    ,SIR_LP_MODE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "SIR_MODE    ,SIR_MODE" "0,1"
            BITFLD.LONG 0x00 5. "THRE_MODE    ,THRE_MODE" "0,1"
            BITFLD.LONG 0x00 4. "AFCE_MODE    ,AFCE_MODE" "0,1"
            BITFLD.LONG 0x00 0.--1. "APB_DATA_WIDTH    ,APB_DATA_WIDTH" "0,1,2,3"
            NEWLINE
    GROUP.LONG 0xf8++0x4
        LINE.LONG 0x00 "UCV,UART Component Version"
            HEXMASK.LONG 0x00 0.--31. "UART_Component_Version    ,UART_Component_Version"
    GROUP.LONG 0xfc++0x03
        LINE.LONG 0x00 "CTR,Component Type Register"
            HEXMASK.LONG 0x00 0.--31. "Peripheral_ID    ,Peripheral_ID"
TREE.END

	TREE "UART1"
    BASE ad:0xb40000
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "RBR,Receive Buffer Register"
            BITFLD.LONG 0x00 0.--7. "RBR    ,RBR"
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "DLL,Divisor Latch (Low) Register"
            BITFLD.LONG 0x00 0.--7. "DLL    ,DLL"
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "THR,Transmit Holding Register"
            BITFLD.LONG 0x00 0.--7. "THR    ,THR"
    GROUP.LONG 0x4++0x04
        LINE.LONG 0x00 "DLH,Divisor Latch (High) Register"
            BITFLD.LONG 0x00 0.--7. "DLH    ,DLH"
    GROUP.LONG 0x4++0x4
        LINE.LONG 0x00 "IER,Interrupt Enable Register"
            BITFLD.LONG 0x00 7. "PTIME    ,PTIME" "0,1"
            BITFLD.LONG 0x00 4. "ELCOLR    ,ELCOLR" "0,1"
            BITFLD.LONG 0x00 3. "EDSSI    ,EDSSI" "0,1"
            BITFLD.LONG 0x00 2. "ELSI    ,ELSI" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "ETBEI    ,ETBEI" "0,1"
            BITFLD.LONG 0x00 0. "ERBFI    ,ERBFI" "0,1"
    GROUP.LONG 0x8++0x04
        LINE.LONG 0x00 "FCR,FIFO Control Register"
            BITFLD.LONG 0x00 6.--7. "RT    ,RT" "0,1,2,3"
            BITFLD.LONG 0x00 4.--5. "TET    ,TET" "0,1,2,3"
            BITFLD.LONG 0x00 3. "DMAM    ,DMAM" "0,1"
            BITFLD.LONG 0x00 2. "XFIFOR    ,XFIFOR" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "RFIFOR    ,RFIFOR" "0,1"
            BITFLD.LONG 0x00 0. "FIFOE    ,FIFOE" "0,1"
    GROUP.LONG 0x8++0x4
        LINE.LONG 0x00 "IIR,Interrupt Identification Register"
            BITFLD.LONG 0x00 6.--7. "FIFOSE    ,FIFOSE" "0,1,2,3"
            BITFLD.LONG 0x00 0.--3. "IID    ,IID"
    GROUP.LONG 0xc++0x4
        LINE.LONG 0x00 "LCR,Line Control Register"
            BITFLD.LONG 0x00 7. "DLAB    ,DLAB" "0,1"
            BITFLD.LONG 0x00 6. "BC    ,BC" "0,1"
            BITFLD.LONG 0x00 5. "SP    ,SP" "0,1"
            BITFLD.LONG 0x00 4. "EPS    ,EPS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "PEN    ,PEN" "0,1"
            BITFLD.LONG 0x00 2. "STOP    ,STOP" "0,1"
            BITFLD.LONG 0x00 0.--1. "DLS    ,DLS" "0,1,2,3"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "MCR,Modem Control Register"
            BITFLD.LONG 0x00 6. "SIRE    ,SIRE" "0,1"
            BITFLD.LONG 0x00 5. "AFCE    ,AFCE" "0,1"
            BITFLD.LONG 0x00 4. "LoopBack    ,LoopBack" "0,1"
            BITFLD.LONG 0x00 3. "OUT2    ,OUT2" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 2. "OUT1    ,OUT1" "0,1"
            BITFLD.LONG 0x00 1. "RTS    ,RTS" "0,1"
            BITFLD.LONG 0x00 0. "DTR    ,DTR" "0,1"
    GROUP.LONG 0x14++0x4
        LINE.LONG 0x00 "LSR,Line Status Register"
            BITFLD.LONG 0x00 7. "RFE    ,RFE" "0,1"
            BITFLD.LONG 0x00 6. "TEMT    ,TEMT" "0,1"
            BITFLD.LONG 0x00 5. "THRE    ,THRE" "0,1"
            BITFLD.LONG 0x00 4. "BI    ,BI" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "FE    ,FE" "0,1"
            BITFLD.LONG 0x00 2. "PE    ,PE" "0,1"
            BITFLD.LONG 0x00 1. "OE    ,OE" "0,1"
            BITFLD.LONG 0x00 0. "DR    ,DR" "0,1"
            NEWLINE
    GROUP.LONG 0x18++0x4
        LINE.LONG 0x00 "MSR,Modem Status Register"
            BITFLD.LONG 0x00 7. "DCD    ,DCD" "0,1"
            BITFLD.LONG 0x00 6. "RI    ,RI" "0,1"
            BITFLD.LONG 0x00 5. "DSR    ,DSR" "0,1"
            BITFLD.LONG 0x00 4. "CTS    ,CTS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "DDCD    ,DDCD" "0,1"
            BITFLD.LONG 0x00 2. "TERI    ,TERI" "0,1"
            BITFLD.LONG 0x00 1. "DDSR    ,DDSR" "0,1"
            BITFLD.LONG 0x00 0. "DCTS    ,DCTS" "0,1"
            NEWLINE
    GROUP.LONG 0x1c++0x4
        LINE.LONG 0x00 "SCR,Scratchpad Register"
            BITFLD.LONG 0x00 0.--7. "SCR    ,SCR"
    GROUP.LONG 0x20++0x4
        LINE.LONG 0x00 "LPDLL,Low Power Divisor Latch Low"
            BITFLD.LONG 0x00 0.--7. "LPDLL    ,LPDLL"
    GROUP.LONG 0x24++0x03
        LINE.LONG 0x00 "LPDLH,Low Power Divisor Latch High"
            BITFLD.LONG 0x00 0.--7. "LPDLH    ,LPDLH"
 
TREE "SRBRn"
	GROUP.LONG 0x30++0x03
        LINE.LONG 0x00 "SRBR0        ,Shadow Receive Buffer Register0"
            BITFLD.LONG 0x00 0.--7. "SRBR0    ,SRBR0"
    GROUP.LONG 0x34++0x03
        LINE.LONG 0x00 "SRBR1        ,Shadow Receive Buffer Register1"
            BITFLD.LONG 0x00 0.--7. "SRBR1    ,SRBR1"			
    GROUP.LONG 0x38++0x03
        LINE.LONG 0x00 "SRBR2        ,Shadow Receive Buffer Register2"
            BITFLD.LONG 0x00 0.--7. "SRBR2    ,SRBR2"			
    GROUP.LONG 0x3C++0x03
        LINE.LONG 0x00 "SRBR3        ,Shadow Receive Buffer Register3"
            BITFLD.LONG 0x00 0.--7. "SRBR3    ,SRBR3"
    GROUP.LONG 0x40++0x03
        LINE.LONG 0x00 "SRBR4        ,Shadow Receive Buffer Register4"
            BITFLD.LONG 0x00 0.--7. "SRBR4    ,SRBR4"
    GROUP.LONG 0x44++0x03
        LINE.LONG 0x00 "SRBR5        ,Shadow Receive Buffer Register5"
            BITFLD.LONG 0x00 0.--7. "SRBR5    ,SRBR5"
    GROUP.LONG 0x48++0x03
        LINE.LONG 0x00 "SRBR6        ,Shadow Receive Buffer Register6"
            BITFLD.LONG 0x00 0.--7. "SRBR6    ,SRBR6"
    GROUP.LONG 0x4C++0x03
        LINE.LONG 0x00 "SRBR7        ,Shadow Receive Buffer Register7"
            BITFLD.LONG 0x00 0.--7. "SRBR7    ,SRBR7"
    GROUP.LONG 0x50++0x03
        LINE.LONG 0x00 "SRBR8        ,Shadow Receive Buffer Register8"
            BITFLD.LONG 0x00 0.--7. "SRBR8    ,SRBR8"
    GROUP.LONG 0x54++0x03
        LINE.LONG 0x00 "SRBR9        ,Shadow Receive Buffer Register9"
            BITFLD.LONG 0x00 0.--7. "SRBR9    ,SRBR9"
    GROUP.LONG 0x58++0x03
        LINE.LONG 0x00 "SRBR10        ,Shadow Receive Buffer Register10"
            BITFLD.LONG 0x00 0.--7. "SRBR10    ,SRBR10"
    GROUP.LONG 0x5C++0x03
        LINE.LONG 0x00 "SRBR11        ,Shadow Receive Buffer Register11"
            BITFLD.LONG 0x00 0.--7. "SRBR11    ,SRBR11"
    GROUP.LONG 0x60++0x03
        LINE.LONG 0x00 "SRBR12        ,Shadow Receive Buffer Register12"
            BITFLD.LONG 0x00 0.--7. "SRBR12    ,SRBR12"
    GROUP.LONG 0x64++0x03
        LINE.LONG 0x00 "SRBR13        ,Shadow Receive Buffer Register13"
            BITFLD.LONG 0x00 0.--7. "SRBR13    ,SRBR13"
    GROUP.LONG 0x68++0x03
        LINE.LONG 0x00 "SRBR14        ,Shadow Receive Buffer Register14"
            BITFLD.LONG 0x00 0.--7. "SRBR14    ,SRBR14"
    GROUP.LONG 0x6C++0x03
        LINE.LONG 0x00 "SRBR15        ,Shadow Receive Buffer Register15"
            BITFLD.LONG 0x00 0.--7. "SRBR15    ,SRBR15"
TREE.END
TREE "STHRn"
	GROUP.LONG 0x30++0x03
        LINE.LONG 0x00 "STHR0        ,Shadow Transmit Holding Register0"
            BITFLD.LONG 0x00 0.--7. "STHR0    ,STHR0"
    GROUP.LONG 0x34++0x03
        LINE.LONG 0x00 "STHR1        ,Shadow Transmit Holding Register1"
            BITFLD.LONG 0x00 0.--7. "STHR1    ,STHR1"			
    GROUP.LONG 0x38++0x03
        LINE.LONG 0x00 "STHR2        ,Shadow Transmit Holding Register2"
            BITFLD.LONG 0x00 0.--7. "STHR2    ,STHR2"			
    GROUP.LONG 0x3C++0x03
        LINE.LONG 0x00 "STHR3        ,Shadow Transmit Holding Register3"
            BITFLD.LONG 0x00 0.--7. "STHR3    ,STHR3"
    GROUP.LONG 0x40++0x03
        LINE.LONG 0x00 "STHR4        ,Shadow Transmit Holding Register4"
            BITFLD.LONG 0x00 0.--7. "STHR4    ,STHR4"
    GROUP.LONG 0x44++0x03
        LINE.LONG 0x00 "STHR5        ,Shadow Transmit Holding Register5"
            BITFLD.LONG 0x00 0.--7. "STHR5    ,STHR5"
    GROUP.LONG 0x48++0x03
        LINE.LONG 0x00 "STHR6        ,Shadow Transmit Holding Register6"
            BITFLD.LONG 0x00 0.--7. "STHR6    ,STHR6"
    GROUP.LONG 0x4C++0x03
        LINE.LONG 0x00 "STHR7        ,Shadow Transmit Holding Register7"
            BITFLD.LONG 0x00 0.--7. "STHR7    ,STHR7"
    GROUP.LONG 0x50++0x03
        LINE.LONG 0x00 "STHR8        ,Shadow Transmit Holding Register8"
            BITFLD.LONG 0x00 0.--7. "STHR8    ,STHR8"
    GROUP.LONG 0x54++0x03
        LINE.LONG 0x00 "STHR9        ,Shadow Transmit Holding Register9"
            BITFLD.LONG 0x00 0.--7. "STHR9    ,STHR9"
    GROUP.LONG 0x58++0x03
        LINE.LONG 0x00 "STHR10        ,Shadow Transmit Holding Register10"
            BITFLD.LONG 0x00 0.--7. "STHR10    ,STHR10"
    GROUP.LONG 0x5C++0x03
        LINE.LONG 0x00 "STHR11        ,Shadow Transmit Holding Register11"
            BITFLD.LONG 0x00 0.--7. "STHR11    ,STHR11"
    GROUP.LONG 0x60++0x03
        LINE.LONG 0x00 "STHR12        ,Shadow Transmit Holding Register12"
            BITFLD.LONG 0x00 0.--7. "STHR12    ,STHR12"
    GROUP.LONG 0x64++0x03
        LINE.LONG 0x00 "STHR13        ,Shadow Transmit Holding Register13"
            BITFLD.LONG 0x00 0.--7. "STHR13    ,STHR13"
    GROUP.LONG 0x68++0x03
        LINE.LONG 0x00 "STHR14        ,Shadow Transmit Holding Register14"
            BITFLD.LONG 0x00 0.--7. "STHR14    ,STHR14"
    GROUP.LONG 0x6C++0x03
        LINE.LONG 0x00 "STHR15        ,Shadow Transmit Holding Register15"
            BITFLD.LONG 0x00 0.--7. "STHR15    ,STHR15"			
TREE.END
    GROUP.LONG 0x70++0x4
        LINE.LONG 0x00 "FAR,FIFO Access Register"
            BITFLD.LONG 0x00 0. "FAR    ,FAR" "0,1"
    GROUP.LONG 0x74++0x4
        LINE.LONG 0x00 "TFR,Transmit FIFO Read"
            BITFLD.LONG 0x00 0.--7. "TFR    ,TFR"
    GROUP.LONG 0x78++0x4
        LINE.LONG 0x00 "RFW,Receive FIFO Write"
            BITFLD.LONG 0x00 9. "RFFE    ,RFFE" "0,1"
            BITFLD.LONG 0x00 8. "RFPE    ,RFPE" "0,1"
            BITFLD.LONG 0x00 0.--7. "RFWD    ,RFWD"
    GROUP.LONG 0x7c++0x4
        LINE.LONG 0x00 "USR,UART Status register"
            BITFLD.LONG 0x00 4. "RFF    ,RFF" "0,1"
            BITFLD.LONG 0x00 3. "RFNE    ,RFNE" "0,1"
            BITFLD.LONG 0x00 2. "TFE    ,TFE" "0,1"
            BITFLD.LONG 0x00 1. "TFNF    ,TFNF" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0. "BUSY    ,BUSY" "0,1"
    GROUP.LONG 0x80++0x4
        LINE.LONG 0x00 "TFL,Transmit FIFO Level"
            BITFLD.LONG 0x00 0.--5. "TFL    ,TFL"
    GROUP.LONG 0x84++0x4
        LINE.LONG 0x00 "RFL,Receive FIFO Level"
            BITFLD.LONG 0x00 0.--5. "RFL    ,RFL"
    GROUP.LONG 0x88++0x4
        LINE.LONG 0x00 "SRR,Software Reset Register"
            BITFLD.LONG 0x00 2. "XFR    ,XFR" "0,1"
            BITFLD.LONG 0x00 1. "RFR    ,RFR" "0,1"
            BITFLD.LONG 0x00 0. "UR    ,UR" "0,1"
    GROUP.LONG 0x8c++0x4
        LINE.LONG 0x00 "SRTS,Shadow Request to Send"
            BITFLD.LONG 0x00 0. "SRTS    ,SRTS" "0,1"
    GROUP.LONG 0x90++0x4
        LINE.LONG 0x00 "SBCR,Shadow Break Control Register"
            BITFLD.LONG 0x00 0. "SBCB    ,SBCB" "0,1"
    GROUP.LONG 0x94++0x4
        LINE.LONG 0x00 "SDMAM,Shadow DMA Mode Register"
            BITFLD.LONG 0x00 0. "SDMAM    ,SDMAM" "0,1"
    GROUP.LONG 0x98++0x4
        LINE.LONG 0x00 "SFE,Shadow FIFO Enable Register"
            BITFLD.LONG 0x00 0. "SFE    ,SFE" "0,1"
    GROUP.LONG 0x9c++0x4
        LINE.LONG 0x00 "SRT,Shadow RCVR Trigger Register"
            BITFLD.LONG 0x00 0.--1. "SRT    ,SRT" "0,1,2,3"
    GROUP.LONG 0xa0++0x4
        LINE.LONG 0x00 "STET,Shadow TX Empty Trigger Register"
            BITFLD.LONG 0x00 0.--1. "STET    ,STET" "0,1,2,3"
    GROUP.LONG 0xa4++0x50
        LINE.LONG 0x00 "HTX,Halt TX Register"
            BITFLD.LONG 0x00 0. "HTX    ,HTX" "0,1"
    GROUP.LONG 0xf4++0x4
        LINE.LONG 0x00 "CPR,Component Parameter Register"
            BITFLD.LONG 0x00 16.--23. "FIFO_MODE    ,FIFO_MODE"
            BITFLD.LONG 0x00 13. "DMA_EXTRA    ,DMA_EXTRA" "0,1"
            BITFLD.LONG 0x00 12. "UART_ADD_ENCODED_PARAMS    ,UART_ADD_ENCODED_PARAMS" "0,1"
            BITFLD.LONG 0x00 11. "SHADOW    ,SHADOW" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 10. "FIFO_STAT    ,FIFO_STAT" "0,1"
            BITFLD.LONG 0x00 9. "FIFO_ACCESS    ,FIFO_ACCESS" "0,1"
            BITFLD.LONG 0x00 8. "ADDITIONAL_FEAT    ,ADDITIONAL_FEAT" "0,1"
            BITFLD.LONG 0x00 7. "SIR_LP_MODE    ,SIR_LP_MODE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "SIR_MODE    ,SIR_MODE" "0,1"
            BITFLD.LONG 0x00 5. "THRE_MODE    ,THRE_MODE" "0,1"
            BITFLD.LONG 0x00 4. "AFCE_MODE    ,AFCE_MODE" "0,1"
            BITFLD.LONG 0x00 0.--1. "APB_DATA_WIDTH    ,APB_DATA_WIDTH" "0,1,2,3"
            NEWLINE
    GROUP.LONG 0xf8++0x4
        LINE.LONG 0x00 "UCV,UART Component Version"
            HEXMASK.LONG 0x00 0.--31. "UART_Component_Version    ,UART_Component_Version"
    GROUP.LONG 0xfc++0x03
        LINE.LONG 0x00 "CTR,Component Type Register"
            HEXMASK.LONG 0x00 0.--31. "Peripheral_ID    ,Peripheral_ID"
TREE.END


TREE.END

TREE "I2C MODULE"
    BASE ad:0xb50000
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "IC_CON,I2C Control Register"
            BITFLD.LONG 0x00 10. "STOP_DET_IF_MASTER_ACTIVE    ,STOP_DET_IF_MASTER_ACTIVE" "0,1"
            BITFLD.LONG 0x00 9. "RX_FIFO_FULL_HLD_CTRL    ,RX_FIFO_FULL_HLD_CTRL" "0,1"
            BITFLD.LONG 0x00 8. "TX_EMPTY_CTRL    ,TX_EMPTY_CTRL" "0,1"
            BITFLD.LONG 0x00 7. "IC_CON_RSVD    ,IC_CON_RSVD" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 6. "IC_SLAVE_DISABLE    ,IC_SLAVE_DISABLE" "0,1"
            BITFLD.LONG 0x00 5. "IC_RESTART_EN    ,IC_RESTART_EN" "0,1"
            BITFLD.LONG 0x00 4. "IC_10BITADDR_MASTER    ,IC_10BITADDR_MASTER" "0,1"
            BITFLD.LONG 0x00 3. "IC_CON_RSVD    ,IC_CON_RSVD" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1.--2. "SPEED    ,SPEED" "0,1,2,3"
            BITFLD.LONG 0x00 0. "MASTER_MODE    ,MASTER_MODE" "0,1"
    GROUP.LONG 0x4++0x8
        LINE.LONG 0x00 "IC_TAR,I2C Target Address Register"
            BITFLD.LONG 0x00 12. "IC_10BITADDR_MASTER    ,IC_10BITADDR_MASTER" "0,1"
            BITFLD.LONG 0x00 10.--11. "IC_TAR_RSVD    ,IC_TAR_RSVD" "0,1,2,3"
            BITFLD.LONG 0x00 0.--9. "IC_TAR    ,IC_TAR"
    GROUP.LONG 0xc++0x4
        LINE.LONG 0x00 "IC_HS_MADDR,I2C High Speed Master Mode Code Address Register"
            BITFLD.LONG 0x00 0.--2. "IC_HS_MAR    ,IC_HS_MAR"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "IC_DATA_CMD,I2C Rx/Tx Data Buffer and Command Register"
            BITFLD.LONG 0x00 11. "FIRST_DATA_BYTE    ,FIRST_DATA_BYTE" "0,1"
            BITFLD.LONG 0x00 10. "RESTART    ,RESTART" "0,1"
            BITFLD.LONG 0x00 9. "STOP    ,STOP" "0,1"
            BITFLD.LONG 0x00 8. "CMD    ,CMD" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0.--7. "DAT    ,DAT"
    GROUP.LONG 0x14++0x4
        LINE.LONG 0x00 "IC_SS_SCL_HCNT,Standard Speed I2C Clock SCL High Count Register"
            BITFLD.LONG 0x00 0.--15. "IC_SS_SCL_HCNT    ,IC_SS_SCL_HCNT"
    GROUP.LONG 0x18++0x4
        LINE.LONG 0x00 "IC_SS_SCL_LCNT,Standard Speed I2C Clock SCL Low Count Register"
            BITFLD.LONG 0x00 0.--15. "IC_SS_SCL_LCNT    ,IC_SS_SCL_LCNT"
    GROUP.LONG 0x1c++0x4
        LINE.LONG 0x00 "IC_FS_SCL_HCNT,Standard Speed I2C Clock SCL High Count Register"
            BITFLD.LONG 0x00 0.--15. "IC_FS_SCL_HCNT    ,IC_FS_SCL_HCNT"
    GROUP.LONG 0x20++0x4
        LINE.LONG 0x00 "IC_FS_SCL_LCNT,Fast Mode or Fast Mode Plus I2C Clock SCL Low Count Register"
            BITFLD.LONG 0x00 0.--15. "IC_FS_SCL_LCNT    ,IC_FS_SCL_LCNT"
    GROUP.LONG 0x24++0x4
        LINE.LONG 0x00 "IC_HS_SCL_HCNT,Fast Mode or Fast Mode Plus I2C Clock SCL High Count Register"
            BITFLD.LONG 0x00 0.--15. "IC_HS_SCL_HCNT    ,IC_HS_SCL_HCNT"
    GROUP.LONG 0x28++0x4
        LINE.LONG 0x00 "IC_HS_SCL_LCNT,High Speed I2C Clock SCL Low Count Register"
            BITFLD.LONG 0x00 0.--15. "IC_HS_SCL_LCNT    ,IC_HS_SCL_LCNT"
    GROUP.LONG 0x2c++0x4
        LINE.LONG 0x00 "IC_INTR_STAT,I2C Interrupt Status Register"
            BITFLD.LONG 0x00 11. "R_GEN_CALL    ,R_GEN_CALL" "0,1"
            BITFLD.LONG 0x00 10. "R_START_DET    ,R_START_DET" "0,1"
            BITFLD.LONG 0x00 9. "R_STOP_DET    ,R_STOP_DET" "0,1"
            BITFLD.LONG 0x00 8. "R_ACTIVITY    ,R_ACTIVITY" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "IC_RAW_INTR_STAT_RSVD    ,IC_RAW_INTR_STAT_RSVD" "0,1"
            BITFLD.LONG 0x00 6. "R_TX_ABRT    ,R_TX_ABRT" "0,1"
            BITFLD.LONG 0x00 5. "IC_RAW_INTR_STAT_RSVD    ,IC_RAW_INTR_STAT_RSVD" "0,1"
            BITFLD.LONG 0x00 4. "R_TX_EMPTY    ,R_TX_EMPTY" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "R_TX_OVER    ,R_TX_OVER" "0,1"
            BITFLD.LONG 0x00 2. "R_RX_FULL    ,R_RX_FULL" "0,1"
            BITFLD.LONG 0x00 1. "R_RX_OVER    ,R_RX_OVER" "0,1"
            BITFLD.LONG 0x00 0. "R_RX_UNDER    ,R_RX_UNDER" "0,1"
            NEWLINE
    GROUP.LONG 0x30++0x4
        LINE.LONG 0x00 "IC_INTR_MASK,I2C Interrupt Mask Register"
            BITFLD.LONG 0x00 11. "M_GEN_CALL    ,M_GEN_CALL" "0,1"
            BITFLD.LONG 0x00 10. "M_START_DET    ,M_START_DET" "0,1"
            BITFLD.LONG 0x00 9. "M_STOP_DET    ,M_STOP_DET" "0,1"
            BITFLD.LONG 0x00 8. "M_ACTIVITY    ,M_ACTIVITY" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 7. "IC_RAW_INTR_STAT_RSVD    ,IC_RAW_INTR_STAT_RSVD" "0,1"
            BITFLD.LONG 0x00 6. "M_TX_ABRT    ,M_TX_ABRT" "0,1"
            BITFLD.LONG 0x00 5. "IC_RAW_INTR_STAT_RSVD    ,IC_RAW_INTR_STAT_RSVD" "0,1"
            BITFLD.LONG 0x00 4. "M_TX_EMPTY    ,M_TX_EMPTY" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "M_TX_OVER    ,M_TX_OVER" "0,1"
            BITFLD.LONG 0x00 2. "M_RX_FULL    ,M_RX_FULL" "0,1"
            BITFLD.LONG 0x00 1. "M_RX_OVER    ,M_RX_OVER" "0,1"
            BITFLD.LONG 0x00 0. "M_RX_UNDER    ,M_RX_UNDER" "0,1"
            NEWLINE
    GROUP.LONG 0x34++0x4
        LINE.LONG 0x00 "IC_RAW_INTR_STAT,I2C Raw Interrupt Status Register"
            BITFLD.LONG 0x00 11. "GEN_CALL    ,GEN_CALL" "0,1"
            BITFLD.LONG 0x00 10. "START_DET    ,START_DET" "0,1"
            BITFLD.LONG 0x00 9. "STOP_DET    ,STOP_DET" "0,1"
            BITFLD.LONG 0x00 8. "ACTIVITY    ,ACTIVITY" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 7. "IC_RAW_INTR_STAT_RSVD    ,IC_RAW_INTR_STAT_RSVD" "0,1"
            BITFLD.LONG 0x00 6. "TX_ABRT    ,TX_ABRT" "0,1"
            BITFLD.LONG 0x00 5. "IC_RAW_INTR_STAT_RSVD    ,IC_RAW_INTR_STAT_RSVD" "0,1"
            BITFLD.LONG 0x00 4. "TX_EMPTY    ,TX_EMPTY" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 3. "TX_OVER    ,TX_OVER" "0,1"
            BITFLD.LONG 0x00 2. "RX_FULL    ,RX_FULL" "0,1"
            BITFLD.LONG 0x00 1. "RX_OVER    ,RX_OVER" "0,1"
            BITFLD.LONG 0x00 0. "RX_UNDER    ,RX_UNDER" "0,1"
            NEWLINE
    GROUP.LONG 0x38++0x4
        LINE.LONG 0x00 "IC_RX_TL,I2C Receive FIFO Threshold Register"
            BITFLD.LONG 0x00 0.--7. "RX_TL    ,RX_TL"
    GROUP.LONG 0x3c++0x4
        LINE.LONG 0x00 "IC_TX_TL,I2C Transmit FIFO Threshold Register"
            BITFLD.LONG 0x00 0.--7. "TX_TL    ,TX_TL"
    GROUP.LONG 0x40++0x4
        LINE.LONG 0x00 "IC_CLR_INTR,Clear Individual Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_INTR    ,CLR_INTR" "0,1"
    GROUP.LONG 0x44++0x4
        LINE.LONG 0x00 "IC_CLR_RX_UNDER,Clear RX_UNDER Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_RX_UNDER    ,CLR_RX_UNDER" "0,1"
    GROUP.LONG 0x48++0x4
        LINE.LONG 0x00 "IC_CLR_RX_OVER,Clear RX_OVER Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_RX_OVER    ,CLR_RX_OVER" "0,1"
    GROUP.LONG 0x4c++0x8
        LINE.LONG 0x00 "IC_CLR_TX_OVER,Clear TX_OVER Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_TX_OVER    ,CLR_TX_OVER" "0,1"
    GROUP.LONG 0x54++0x8
        LINE.LONG 0x00 "IC_CLR_TX_ABRT,Clear TX_ABRT Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_TX_ABRT    ,CLR_TX_ABRT" "0,1"
    GROUP.LONG 0x5c++0x4
        LINE.LONG 0x00 "IC_CLR_ACTIVITY,Clear ACTIVITY Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_ACTIVITY    ,CLR_ACTIVITY" "0,1"
    GROUP.LONG 0x60++0x4
        LINE.LONG 0x00 "IC_CLR_STOP_DET,Clear STOP_DET Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_STOP_DET    ,CLR_STOP_DET" "0,1"
    GROUP.LONG 0x64++0x24
        LINE.LONG 0x00 "IC_CLR_START_DET,Clear START_DET Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_START_DET    ,CLR_START_DET" "0,1"
    GROUP.LONG 0x88++0x1c
        LINE.LONG 0x00 "IC_CLR_GEN_CALL,Clear GEN_CALL Interrupt Register"
            BITFLD.LONG 0x00 0. "CLR_GEN_CALL    ,CLR_GEN_CALL" "0,1"
    GROUP.LONG 0x6c++0x4
        LINE.LONG 0x00 "IC_ENABLE,I2C Enable Register"
            BITFLD.LONG 0x00 2. "TX_CMD_BLOCK    ,TX_CMD_BLOCK" "0,1"
            BITFLD.LONG 0x00 1. "ABORT    ,ABORT" "0,1"
            BITFLD.LONG 0x00 0. "ENABLE    ,ENABLE" "0,1"
    GROUP.LONG 0x70++0x4
        LINE.LONG 0x00 "IC_STATUS,I2C STATUS Register"
            BITFLD.LONG 0x00 5. "MST_ACTIVITY    ,MST_ACTIVITY" "0,1"
            BITFLD.LONG 0x00 4. "RFF    ,RFF" "0,1"
            BITFLD.LONG 0x00 3. "RFNE    ,RFNE" "0,1"
            BITFLD.LONG 0x00 2. "TFE    ,TFE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TFNF    ,TFNF" "0,1"
            BITFLD.LONG 0x00 0. "ACTIVITY    ,ACTIVITY" "0,1"
    GROUP.LONG 0x74++0x4
        LINE.LONG 0x00 "IC_TXFLR,I2C Transmit FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "TXFLR    ,TXFLR"
    GROUP.LONG 0x78++0x4
        LINE.LONG 0x00 "IC_RXFLR,I2C Receive FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "RXFLR    ,RXFLR"
    GROUP.LONG 0x7c++0x4
        LINE.LONG 0x00 "IC_SDA_HOLD,I2C SDA Hold Time Length Register"
            BITFLD.LONG 0x00 16.--23. "IC_SDA_RX_HOLD    ,IC_SDA_RX_HOLD"
            BITFLD.LONG 0x00 0.--15. "IC_SDA_TX_HOLD    ,IC_SDA_TX_HOLD"
    GROUP.LONG 0x80++0x1c
        LINE.LONG 0x00 "IC_TX_ABRT_SOURCE,I2C Transmit Abort Source Register"
            BITFLD.LONG 0x00 23.--31. "TX_FLUSH_CNT    ,TX_FLUSH_CNT"
            BITFLD.LONG 0x00 17.--22. "IC_TX_ABRT_SOURCE_RSVD    ,IC_TX_ABRT_SOURCE_RSVD"
            BITFLD.LONG 0x00 16. "ABRT_USER_ABRT    ,ABRT_USER_ABRT" "0,1"
            BITFLD.LONG 0x00 13.--15. "IC_TX_ABRT_SOURCE_RSVD    ,IC_TX_ABRT_SOURCE_RSVD"
            NEWLINE
            BITFLD.LONG 0x00 12. "ARB_LOST    ,ARB_LOST" "0,1"
            BITFLD.LONG 0x00 11. "ABRT_MASTER_DIS    ,ABRT_MASTER_DIS" "0,1"
            BITFLD.LONG 0x00 10. "ABRT_10B_RD_NORSTRT    ,ABRT_10B_RD_NORSTRT" "0,1"
            BITFLD.LONG 0x00 9. "ABRT_SBYTE_NORSTRT    ,ABRT_SBYTE_NORSTRT" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 8. "ABRT_HS_NORSTRT    ,ABRT_HS_NORSTRT" "0,1"
            BITFLD.LONG 0x00 7. "ABRT_SBYTE_ACKDET    ,ABRT_SBYTE_ACKDET" "0,1"
            BITFLD.LONG 0x00 6. "ABRT_HS_ACKDET    ,ABRT_HS_ACKDET" "0,1"
            BITFLD.LONG 0x00 5. "ABRT_GCALL_READ    ,ABRT_GCALL_READ" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 4. "ABRT_GCALL_NOACK    ,ABRT_GCALL_NOACK" "0,1"
            BITFLD.LONG 0x00 3. "ABRT_TXDATA_NOACK    ,ABRT_TXDATA_NOACK" "0,1"
            BITFLD.LONG 0x00 2. "ABRT_10ADDR2_NOACK    ,ABRT_10ADDR2_NOACK" "0,1"
            BITFLD.LONG 0x00 1. "ABRT_10ADDR1_NOACK    ,ABRT_10ADDR1_NOACK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 0. "ABRT_7B_ADDR_NOACK    ,ABRT_7B_ADDR_NOACK" "0,1"
    GROUP.LONG 0x9c++0x4
        LINE.LONG 0x00 "IC_ENABLE_STATUS,I2C Enable Status Register"
            BITFLD.LONG 0x00 0. "IC_EN    ,IC_EN" "0,1"
    GROUP.LONG 0xa0++0x4
        LINE.LONG 0x00 "IC_FS_SPKLEN,I2C SS FS or FM+ spike suppression limit"
            BITFLD.LONG 0x00 0.--7. "IC_FS_SPKLEN    ,IC_FS_SPKLEN"
    GROUP.LONG 0xa4++0x4
        LINE.LONG 0x00 "IC_HS_SPKLEN,I2C HS spike suppression limit register"
            BITFLD.LONG 0x00 0.--7. "IC_HS_SPKLEN    ,IC_HS_SPKLEN"
    GROUP.LONG 0xf4++0x4
        LINE.LONG 0x00 "IC_COMP_PARAM_1,Component Parameter Register 1"
            BITFLD.LONG 0x00 16.--23. "TX_BUFFER_DEPTH    ,TX_BUFFER_DEPTH"
            BITFLD.LONG 0x00 8.--15. "RX_BUFFER_DEPTH    ,RX_BUFFER_DEPTH"
            BITFLD.LONG 0x00 7. "ADD_ENCODED_PARAMS    ,ADD_ENCODED_PARAMS" "0,1"
            BITFLD.LONG 0x00 6. "IC_COMP_PARAM_1_RSVD    ,IC_COMP_PARAM_1_RSVD" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "INTR_IO    ,INTR_IO" "0,1"
            BITFLD.LONG 0x00 4. "HC_COUNT_VALUES    ,HC_COUNT_VALUES" "0,1"
            BITFLD.LONG 0x00 2.--3. "MAX_SPEED_MODE    ,MAX_SPEED_MODE" "0,1,2,3"
            BITFLD.LONG 0x00 0.--1. "APB_DATA_WIDTH    ,APB_DATA_WIDTH" "0,1,2,3"
            NEWLINE
    GROUP.LONG 0xf8++0x4
        LINE.LONG 0x00 "IC_COMP_VERSION,I2C Component Version Register"
            hexmask.LONG 0x00 0.--31. "IC_COMP_VERSION    ,IC_COMP_VERSION"
    GROUP.LONG 0xfc++0x03
        LINE.LONG 0x00 "IC_COMP_TYPE,I2C Component Type Register"
            hexmask.LONG 0x00 0.--31. "IC_COMP_TYPE    ,IC_COMP_TYPE"
TREE.END




TREE "GPIO MODULE"
    BASE ad:0xbe0000
    GROUP.LONG 0x0++0x4
        LINE.LONG 0x00 "GPIO_SWPORTA_DR,Port A data register"
            BITFLD.LONG 0x00 0.--15. "GPIO_SWPORTA_DDR    ,GPIO_SWPORTA_DDR"
    GROUP.LONG 0x4++0x8
        LINE.LONG 0x00 "GPIO_SWPORTA_DDR, Port A Data Direction Register"
            BITFLD.LONG 0x00 0.--15. "GPIO_SWPORTA_DDR    ,GPIO_SWPORTA_DDR"
    GROUP.LONG 0xc++0x4
        LINE.LONG 0x00 "GPIO_SWPORTB_DR,Port B data register"
            BITFLD.LONG 0x00 0.--15. "GPIO_SWPORTB_DR    ,GPIO_SWPORTB_DR"
    GROUP.LONG 0x10++0x20
        LINE.LONG 0x00 "GPIO_SWPORTB_DDR,Port B Data Direction Register"
            BITFLD.LONG 0x00 0.--15. "GPIO_SWPORTB_DDR    ,GPIO_SWPORTB_DDR"
    GROUP.LONG 0x30++0x4
        LINE.LONG 0x00 "GPIO_INTEN,Interrupt enable register"
            BITFLD.LONG 0x00 0.--15. "GPIO_INTEN    ,GPIO_INTEN"
    GROUP.LONG 0x34++0x4
        LINE.LONG 0x00 "GPIO_INTMASK,Interrupt mask register"
            BITFLD.LONG 0x00 0.--15. "GPIO_INTMASK    ,GPIO_INTMASK"
    GROUP.LONG 0x38++0x4
        LINE.LONG 0x00 "GPIO_INTTYPE_LEVEL,Interrupt level "
            BITFLD.LONG 0x00 0.--15. "GPIO_INTTYPE_LEVEL    ,GPIO_INTTYPE_LEVEL"
    GROUP.LONG 0x3c++0x4
        LINE.LONG 0x00 "GPIO_INT_POLARITY,Interrupt polarity "
            BITFLD.LONG 0x00 0.--15. "GPIO_INT_POLARITY    ,GPIO_INT_POLARITY"
    GROUP.LONG 0x40++0x4
        LINE.LONG 0x00 "GPIO_INTSTATUS,Interrupt status "
            BITFLD.LONG 0x00 0.--15. "GPIO_INTSTATUS    ,GPIO_INTSTATUS"
    GROUP.LONG 0x44++0x4
        LINE.LONG 0x00 "GPIO_RAW_INTSTATUS,Raw interrupt status "
            BITFLD.LONG 0x00 0.--15. "GPIO_RAW_INTSTATUS    ,GPIO_RAW_INTSTATUS"
    GROUP.LONG 0x48++0x4
        LINE.LONG 0x00 "GPIO_DEBOUNCE,Debounce enable "
            BITFLD.LONG 0x00 0.--15. "GPIO_DEBOUNCE    ,GPIO_DEBOUNCE"
    GROUP.LONG 0x4c++0x4
        LINE.LONG 0x00 "GPIO_PORTA_EOI,Port A clear interrupt register"
            BITFLD.LONG 0x00 0.--15. "GPIO_PORTA_EOI    ,GPIO_PORTA_EOI"
    GROUP.LONG 0x50++0x4
        LINE.LONG 0x00 "GPIO_EXT_PORTA,External port A register"
            BITFLD.LONG 0x00 0.--15. "GPIO_EXT_PORTA    ,GPIO_EXT_PORTA"
    GROUP.LONG 0x54++0xc
        LINE.LONG 0x00 "GPIO_EXT_PORTB,External port B register"
            BITFLD.LONG 0x00 0.--15. "GPIO_EXT_PORTB    ,GPIO_EXT_PORTB"
    GROUP.LONG 0x60++0x4
        LINE.LONG 0x00 "GPIO_LS_SYNC,Synchronization level "
            BITFLD.LONG 0x00 0. "GPIO_LS_SYNC    ,GPIO_LS_SYNC" "0,1"
    GROUP.LONG 0x64++0x4
        LINE.LONG 0x00 "GPIO_ID_CODE,GPIO ID code"
            HEXMASK.LONG 0x00 0.--31. "GPIO_ID_CODE    ,GPIO_ID_CODE"
    GROUP.LONG 0x68++0x4
        LINE.LONG 0x00 "GPIO_INT_BOTHEDGE,Interrupt Both Edge type"
            BITFLD.LONG 0x00 0.--15. "GPIO_INT_BOTHEDGE    ,GPIO_INT_BOTHEDGE"
    GROUP.LONG 0x6c++0x4
        LINE.LONG 0x00 "GPIO_VER_ID_CODE,GPIO Component Version"
            HEXMASK.LONG 0x00 0.--31. "GPIO_VER_ID_CODE    ,GPIO_VER_ID_CODE"
    GROUP.LONG 0x70++0x4
        LINE.LONG 0x00 "GPIO_CONFIG_REG2, GPIO Configuration Register 2"
            BITFLD.LONG 0x00 5.--9. "ENCODED_ID_PWIDTH_B    ,ENCODED_ID_PWIDTH_B"
            BITFLD.LONG 0x00 0.--4. "ENCODED_ID_PWIDTH_A    ,ENCODED_ID_PWIDTH_A"
    GROUP.LONG 0x74++0x03
        LINE.LONG 0x00 "GPIO_CONFIG_REG1, GPIO Configuration Register 1"
            BITFLD.LONG 0x00 21. " INTERRUPT_BOTH_EDGE_TYPE    , INTERRUPT_BOTH_EDGE_TYPE" "0,1"
            BITFLD.LONG 0x00 16.--20. "ENCODED_ID_WIDTH    ,ENCODED_ID_WIDTH"
            BITFLD.LONG 0x00 15. "GPIO_ID    ,GPIO_ID" "0,1"
            BITFLD.LONG 0x00 14. "ADD_ENCODED_PARAMS    ,ADD_ENCODED_PARAMS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 13. "DEBOUNCE    ,DEBOUNCE" "0,1"
            BITFLD.LONG 0x00 12. " PORTA_INTR    , PORTA_INTR" "0,1"
            BITFLD.LONG 0x00 9. "HW_PORTB    ,HW_PORTB" "0,1"
            BITFLD.LONG 0x00 8. "HW_PORTA    ,HW_PORTA" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 5. "PORTB_SINGLE_CTL    ,PORTB_SINGLE_CTL" "0,1"
            BITFLD.LONG 0x00 4. "PORTA_SINGLE_CTL    ,PORTA_SINGLE_CTL" "0,1"
            BITFLD.LONG 0x00 2.--3. "NUM_PORTS    ,NUM_PORTS" "0,1,2,3"
            BITFLD.LONG 0x00 0.--1. "APB_DATA_WIDTH    ,APB_DATA_WIDTH" "0,1,2,3"
            NEWLINE
TREE.END

TREE "PWM module"
TREE "PWM MODULE CHANNEL1"
    BASE ad:0xbd0000
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "PWM_TimerNLoadCount (for N = 1; N <= 8),Value to be loaded into Timer N"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount    ,PWM_TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "PWM_TimerNCurrentValue (for N = 1; N <= 8),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "PWM_TimerNCurrentValue    ,PWM_TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "PWM_TimerNControlReg (for N = 1; N <= 8),Control Register for Timer N. "
            BITFLD.LONG 0x00 5.--31. "PWM_RSVD_TimerNControlReg    ,PWM_RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 4. "PWM_TIMER_0N100PWM_EN    ,PWM_TIMER_0N100PWM_EN" "0,1"
            BITFLD.LONG 0x00 3. "PWM_TIMER_PWM    ,PWM_TIMER_PWM" "0,1"
            BITFLD.LONG 0x00 2. "PWM_TIMER_INTERRUPT_MASK    ,PWM_TIMER_INTERRUPT_MASK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "PWM_TIMER_MODE    ,PWM_TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "PWM_TIMER_ENABLE    ,PWM_TIMER_ENABLE" "0,1"
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "PWM_TimerNEOI (for N = 1; N <= 8),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNEOI    ,PWM_RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "PWM_TimerNEOI    ,PWM_TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "PWM_TimerNIntStatus (for N = 1; N <= 8),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNIntStatus    ,PWM_RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "PWM_TimerNIntStatus    ,PWM_TimerNIntStatus" "0,1"

TREE.END

TREE "PWM MODULE CHANNEL2"
    BASE ad:0xbd0014
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "PWM_TimerNLoadCount (for N = 1; N <= 8),Value to be loaded into Timer N"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount    ,PWM_TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "PWM_TimerNCurrentValue (for N = 1; N <= 8),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "PWM_TimerNCurrentValue    ,PWM_TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "PWM_TimerNControlReg (for N = 1; N <= 8),Control Register for Timer N. "
            BITFLD.LONG 0x00 5.--31. "PWM_RSVD_TimerNControlReg    ,PWM_RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 4. "PWM_TIMER_0N100PWM_EN    ,PWM_TIMER_0N100PWM_EN" "0,1"
            BITFLD.LONG 0x00 3. "PWM_TIMER_PWM    ,PWM_TIMER_PWM" "0,1"
            BITFLD.LONG 0x00 2. "PWM_TIMER_INTERRUPT_MASK    ,PWM_TIMER_INTERRUPT_MASK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "PWM_TIMER_MODE    ,PWM_TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "PWM_TIMER_ENABLE    ,PWM_TIMER_ENABLE" "0,1"
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "PWM_TimerNEOI (for N = 1; N <= 8),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNEOI    ,PWM_RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "PWM_TimerNEOI    ,PWM_TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "PWM_TimerNIntStatus (for N = 1; N <= 8),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNIntStatus    ,PWM_RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "PWM_TimerNIntStatus    ,PWM_TimerNIntStatus" "0,1"
TREE.END

TREE "PWM MODULE CHANNEL3"
    BASE ad:0xbd0028
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "PWM_TimerNLoadCount (for N = 1; N <= 8),Value to be loaded into Timer N"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount    ,PWM_TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "PWM_TimerNCurrentValue (for N = 1; N <= 8),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "PWM_TimerNCurrentValue    ,PWM_TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "PWM_TimerNControlReg (for N = 1; N <= 8),Control Register for Timer N. "
            BITFLD.LONG 0x00 5.--31. "PWM_RSVD_TimerNControlReg    ,PWM_RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 4. "PWM_TIMER_0N100PWM_EN    ,PWM_TIMER_0N100PWM_EN" "0,1"
            BITFLD.LONG 0x00 3. "PWM_TIMER_PWM    ,PWM_TIMER_PWM" "0,1"
            BITFLD.LONG 0x00 2. "PWM_TIMER_INTERRUPT_MASK    ,PWM_TIMER_INTERRUPT_MASK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "PWM_TIMER_MODE    ,PWM_TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "PWM_TIMER_ENABLE    ,PWM_TIMER_ENABLE" "0,1"
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "PWM_TimerNEOI (for N = 1; N <= 8),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNEOI    ,PWM_RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "PWM_TimerNEOI    ,PWM_TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "PWM_TimerNIntStatus (for N = 1; N <= 8),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNIntStatus    ,PWM_RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "PWM_TimerNIntStatus    ,PWM_TimerNIntStatus" "0,1"
TREE.END

TREE "PWM MODULE CHANNEL4"
    BASE ad:0xbd003C
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "PWM_TimerNLoadCount (for N = 1; N <= 8),Value to be loaded into Timer N"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount    ,PWM_TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "PWM_TimerNCurrentValue (for N = 1; N <= 8),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "PWM_TimerNCurrentValue    ,PWM_TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "PWM_TimerNControlReg (for N = 1; N <= 8),Control Register for Timer N. "
            BITFLD.LONG 0x00 5.--31. "PWM_RSVD_TimerNControlReg    ,PWM_RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 4. "PWM_TIMER_0N100PWM_EN    ,PWM_TIMER_0N100PWM_EN" "0,1"
            BITFLD.LONG 0x00 3. "PWM_TIMER_PWM    ,PWM_TIMER_PWM" "0,1"
            BITFLD.LONG 0x00 2. "PWM_TIMER_INTERRUPT_MASK    ,PWM_TIMER_INTERRUPT_MASK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "PWM_TIMER_MODE    ,PWM_TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "PWM_TIMER_ENABLE    ,PWM_TIMER_ENABLE" "0,1"
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "PWM_TimerNEOI (for N = 1; N <= 8),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNEOI    ,PWM_RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "PWM_TimerNEOI    ,PWM_TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "PWM_TimerNIntStatus (for N = 1; N <= 8),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNIntStatus    ,PWM_RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "PWM_TimerNIntStatus    ,PWM_TimerNIntStatus" "0,1"
TREE.END

TREE "PWM MODULE CHANNEL5"
    BASE ad:0xbd0050
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "PWM_TimerNLoadCount (for N = 1; N <= 8),Value to be loaded into Timer N"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount    ,PWM_TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "PWM_TimerNCurrentValue (for N = 1; N <= 8),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "PWM_TimerNCurrentValue    ,PWM_TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "PWM_TimerNControlReg (for N = 1; N <= 8),Control Register for Timer N. "
            BITFLD.LONG 0x00 5.--31. "PWM_RSVD_TimerNControlReg    ,PWM_RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 4. "PWM_TIMER_0N100PWM_EN    ,PWM_TIMER_0N100PWM_EN" "0,1"
            BITFLD.LONG 0x00 3. "PWM_TIMER_PWM    ,PWM_TIMER_PWM" "0,1"
            BITFLD.LONG 0x00 2. "PWM_TIMER_INTERRUPT_MASK    ,PWM_TIMER_INTERRUPT_MASK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "PWM_TIMER_MODE    ,PWM_TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "PWM_TIMER_ENABLE    ,PWM_TIMER_ENABLE" "0,1"
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "PWM_TimerNEOI (for N = 1; N <= 8),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNEOI    ,PWM_RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "PWM_TimerNEOI    ,PWM_TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "PWM_TimerNIntStatus (for N = 1; N <= 8),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNIntStatus    ,PWM_RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "PWM_TimerNIntStatus    ,PWM_TimerNIntStatus" "0,1"
TREE.END

TREE "PWM MODULE CHANNEL6"
    BASE ad:0xbd0064
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "PWM_TimerNLoadCount (for N = 1; N <= 8),Value to be loaded into Timer N"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount    ,PWM_TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "PWM_TimerNCurrentValue (for N = 1; N <= 8),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "PWM_TimerNCurrentValue    ,PWM_TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "PWM_TimerNControlReg (for N = 1; N <= 8),Control Register for Timer N. "
            BITFLD.LONG 0x00 5.--31. "PWM_RSVD_TimerNControlReg    ,PWM_RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 4. "PWM_TIMER_0N100PWM_EN    ,PWM_TIMER_0N100PWM_EN" "0,1"
            BITFLD.LONG 0x00 3. "PWM_TIMER_PWM    ,PWM_TIMER_PWM" "0,1"
            BITFLD.LONG 0x00 2. "PWM_TIMER_INTERRUPT_MASK    ,PWM_TIMER_INTERRUPT_MASK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "PWM_TIMER_MODE    ,PWM_TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "PWM_TIMER_ENABLE    ,PWM_TIMER_ENABLE" "0,1"
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "PWM_TimerNEOI (for N = 1; N <= 8),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNEOI    ,PWM_RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "PWM_TimerNEOI    ,PWM_TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "PWM_TimerNIntStatus (for N = 1; N <= 8),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNIntStatus    ,PWM_RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "PWM_TimerNIntStatus    ,PWM_TimerNIntStatus" "0,1"
TREE.END

TREE "PWM MODULE CHANNEL7"
    BASE ad:0xbd0078
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "PWM_TimerNLoadCount (for N = 1; N <= 8),Value to be loaded into Timer N"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount    ,PWM_TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "PWM_TimerNCurrentValue (for N = 1; N <= 8),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "PWM_TimerNCurrentValue    ,PWM_TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "PWM_TimerNControlReg (for N = 1; N <= 8),Control Register for Timer N. "
            BITFLD.LONG 0x00 5.--31. "PWM_RSVD_TimerNControlReg    ,PWM_RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 4. "PWM_TIMER_0N100PWM_EN    ,PWM_TIMER_0N100PWM_EN" "0,1"
            BITFLD.LONG 0x00 3. "PWM_TIMER_PWM    ,PWM_TIMER_PWM" "0,1"
            BITFLD.LONG 0x00 2. "PWM_TIMER_INTERRUPT_MASK    ,PWM_TIMER_INTERRUPT_MASK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "PWM_TIMER_MODE    ,PWM_TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "PWM_TIMER_ENABLE    ,PWM_TIMER_ENABLE" "0,1"
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "PWM_TimerNEOI (for N = 1; N <= 8),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNEOI    ,PWM_RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "PWM_TimerNEOI    ,PWM_TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "PWM_TimerNIntStatus (for N = 1; N <= 8),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNIntStatus    ,PWM_RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "PWM_TimerNIntStatus    ,PWM_TimerNIntStatus" "0,1"
TREE.END

TREE "PWM MODULE CHANNEL8"
    BASE ad:0xbd008C
    GROUP.LONG 0x00++0x4
        LINE.LONG 0x00 "PWM_TimerNLoadCount (for N = 1; N <= 8),Value to be loaded into Timer N"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount    ,PWM_TimerNLoadCount"
    GROUP.LONG 0x04++0x4
        LINE.LONG 0x00 "PWM_TimerNCurrentValue (for N = 1; N <= 8),Current value of Timer N"
            HEXMASK.LONG 0x00 0.--31. "PWM_TimerNCurrentValue    ,PWM_TimerNCurrentValue"
    GROUP.LONG 0x08++0x4
        LINE.LONG 0x00 "PWM_TimerNControlReg (for N = 1; N <= 8),Control Register for Timer N. "
            BITFLD.LONG 0x00 5.--31. "PWM_RSVD_TimerNControlReg    ,PWM_RSVD_TimerNControlReg"
            BITFLD.LONG 0x00 4. "PWM_TIMER_0N100PWM_EN    ,PWM_TIMER_0N100PWM_EN" "0,1"
            BITFLD.LONG 0x00 3. "PWM_TIMER_PWM    ,PWM_TIMER_PWM" "0,1"
            BITFLD.LONG 0x00 2. "PWM_TIMER_INTERRUPT_MASK    ,PWM_TIMER_INTERRUPT_MASK" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "PWM_TIMER_MODE    ,PWM_TIMER_MODE" "0,1"
            BITFLD.LONG 0x00 0. "PWM_TIMER_ENABLE    ,PWM_TIMER_ENABLE" "0,1"
    GROUP.LONG 0x0C++0x4
        LINE.LONG 0x00 "PWM_TimerNEOI (for N = 1; N <= 8),Clears the interrupt from Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNEOI    ,PWM_RSVD_TimerNEOI"
            BITFLD.LONG 0x00 0. "PWM_TimerNEOI    ,PWM_TimerNEOI" "0,1"
    GROUP.LONG 0x10++0x4
        LINE.LONG 0x00 "PWM_TimerNIntStatus (for N = 1; N <= 8),Contains the interrupt status for Timer N"
            BITFLD.LONG 0x00 1.--31. "PWM_RSVD_TimerNIntStatus    ,PWM_RSVD_TimerNIntStatus"
            BITFLD.LONG 0x00 0. "PWM_TimerNIntStatus    ,PWM_TimerNIntStatus" "0,1"
TREE.END

TREE "PWM MODULE OTHERS"
	BASE ad:0xbd0000
    GROUP.LONG 0xa0++0x4
        LINE.LONG 0x00 "PWM_TimersIntStatus,Contains the interrupt status of all timers in the component."
            BITFLD.LONG 0x00 8.--31. "PWM_RSVD_TimersIntStatus    ,PWM_RSVD_TimersIntStatus"
            BITFLD.LONG 0x00 0.--7. "PWM_TimersIntStatus    ,PWM_TimersIntStatus"
    GROUP.LONG 0xa4++0x4
        LINE.LONG 0x00 "PWM_TimersEOI,Returns all zeroes (0) and clears all active interrupts."
            BITFLD.LONG 0x00 8.--31. "PWM_TimersEOI 31to8 Reserved field    ,PWM_TimersEOI 31to8 Reserved field"
            BITFLD.LONG 0x00 0.--7. "PWM_TIMERSEOI    ,PWM_TIMERSEOI"
    GROUP.LONG 0xa8++0x4
        LINE.LONG 0x00 "PWM_TimersRawIntStatus,Contains the unmasked interrupt status of all timers in the component."
            BITFLD.LONG 0x00 8.--31. "PWM_RSVD_TIMERSRAWINTSTAT    ,PWM_RSVD_TIMERSRAWINTSTAT"
            BITFLD.LONG 0x00 0.--7. "PWM_TIMERSRAWINTSTAT    ,PWM_TIMERSRAWINTSTAT"
    GROUP.LONG 0xac++0x03
        LINE.LONG 0x00 "PWM_TIMERS_COMP_VERSION,Current revision number of the PWM component."
            HEXMASK.LONG 0x00 0.--31. "PWM_TIMERSCOMPVERSION    ,PWM_TIMERSCOMPVERSION"
    GROUP.LONG 0xb0++0x03
        LINE.LONG 0x00 "PWM_Timer1LoadCount2 (for N = 1; N <= 8)+C11,Value to be loaded into Timer N counter2"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount2    ,PWM_TimerNLoadCount2"
	GROUP.LONG 0xb4++0x03
        LINE.LONG 0x00 "PWM_Timer2LoadCount2 (for N = 1; N <= 8)+C11,Value to be loaded into Timer N counter2"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount2    ,PWM_TimerNLoadCount2"
    GROUP.LONG 0xb8++0x03
        LINE.LONG 0x00 "PWM_Timer3LoadCount2 (for N = 1; N <= 8)+C11,Value to be loaded into Timer N counter2"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount2    ,PWM_TimerNLoadCount2"
    GROUP.LONG 0xbc++0x03
        LINE.LONG 0x00 "PWM_Timer4LoadCount2 (for N = 1; N <= 8)+C11,Value to be loaded into Timer N counter2"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount2    ,PWM_TimerNLoadCount2"			
    GROUP.LONG 0xc0++0x03
        LINE.LONG 0x00 "PWM_Timer5LoadCount2 (for N = 1; N <= 8)+C11,Value to be loaded into Timer N counter2"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount2    ,PWM_TimerNLoadCount2"
    GROUP.LONG 0xc4++0x03
        LINE.LONG 0x00 "PWM_Timer6LoadCount2 (for N = 1; N <= 8)+C11,Value to be loaded into Timer N counter2"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount2    ,PWM_TimerNLoadCount2"
    GROUP.LONG 0xc8++0x03
        LINE.LONG 0x00 "PWM_Timer7LoadCount2 (for N = 1; N <= 8)+C11,Value to be loaded into Timer N counter2"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount2    ,PWM_TimerNLoadCount2"
    GROUP.LONG 0xcc++0x03
        LINE.LONG 0x00 "PWM_Timer8LoadCount2 (for N = 1; N <= 8)+C11,Value to be loaded into Timer N counter2"
            BITFLD.LONG 0x00 0.--31. "PWM_TimerNLoadCount2    ,PWM_TimerNLoadCount2"
TREE.END
TREE.END

TREE "DMU MODULE"
    BASE ad:0xba0000
    GROUP.LONG 0x000++0x4
        LINE.LONG 0x00 "DMU_CMD_SRC_SEL,Radio Command Source Selection"
            BITFLD.LONG 0x00 0.--1. "CMD_SRC    ,CMD_SRC" "0,1,2,3"
    GROUP.LONG 0x004++0x4
        LINE.LONG 0x00 "DMU_CMD_OUT,Radio Command Write"
            BITFLD.LONG 0x00 15. "CMD_WR    ,CMD_WR" "0,1"
            BITFLD.LONG 0x00 8.--14. "CMD_ADDR    ,CMD_ADDR"
            BITFLD.LONG 0x00 0.--7. "CMD_WR_DAT    ,CMD_WR_DAT"
    GROUP.LONG 0x008++0x4
        LINE.LONG 0x00 "DMU_CMD_IN,Radio Command Read"
            BITFLD.LONG 0x00 0.--7. "CMD_RD_DAT    ,CMD_RD_DAT"
    GROUP.LONG 0x00C++0x4
        LINE.LONG 0x00 "DMU_ADC_RSTN,Radio ADC Resetn Output"
            BITFLD.LONG 0x00 0. "ADC_RSTN    ,ADC_RSTN" "0,1"
    GROUP.LONG 0x010++0x4
        LINE.LONG 0x00 "DMU_ADC_CNT,Radio ADC Count Output"
            BITFLD.LONG 0x00 0.--31. "ADC_CNT    ,ADC_CNT"
    GROUP.LONG 0x014++0x4
        LINE.LONG 0x00 "DMU_FMCW_START_SRC,Radio FMCW Start Sourse"
            BITFLD.LONG 0x00 0. "FMCW_START_SRC    ,FMCW_START_SRC" "0,1"
    GROUP.LONG 0x018++0x4
        LINE.LONG 0x00 "DMU_FMCW_START,Radio FMCW Start"
            BITFLD.LONG 0x00 0. "FMCW_START    ,FMCW_START" "0,1"
    GROUP.LONG 0x01C++0xe4
        LINE.LONG 0x00 "DMU_FMCW_STATUS,Radio FMCW Status"
            BITFLD.LONG 0x00 2. "FMCW_STA_DN    ,FMCW_STA_DN" "0,1"
            BITFLD.LONG 0x00 1. "FMCW_STA_IDLE    ,FMCW_STA_IDLE" "0,1"
            BITFLD.LONG 0x00 0. "FMCW_STA_UP    ,FMCW_STA_UP" "0,1"
    GROUP.LONG 0x100++0x4
        LINE.LONG 0x00 "DMU_DBG_SRC,DebugBus Source"
            BITFLD.LONG 0x00 0.--2. "DBG_SRC    ,DBG_SRC"
    GROUP.LONG 0x104++0x4
        LINE.LONG 0x00 "DMU_DBG_VAL_OEN,DebugBus Valid Output Enable"
            BITFLD.LONG 0x00 0.--1. "DBG_VAL_OEN    ,DBG_VAL_OEN" "0,1,2,3"
    GROUP.LONG 0x108++0x4
        LINE.LONG 0x00 "DMU_DBG_DAT_OEN,DebugBus Data Ouput Enable"
            HEXMASK.LONG 0x00 0.--31. "DBG_DAT_OEN    ,DBG_DAT_OEN"
    GROUP.LONG 0x10C++0x4
        LINE.LONG 0x00 "DMU_DBG_DOUT,DebugBus Output Data"
            BITFLD.LONG 0x00 0.--31. "DBG_DOUT    ,DBG_DOUT"
    GROUP.LONG 0x110++0x4
        LINE.LONG 0x00 "DMU_DBG_DIN,DebugBus Input Data"
            HEXMASK.LONG 0x00 0.--31. "DBG_DIN    ,DBG_DIN"
    GROUP.LONG 0x114++0x4
        LINE.LONG 0x00 "DMU_HIL_ENA,Hardware in Loop Enable"
            BITFLD.LONG 0x00 0. "HIL_ENA    ,HIL_ENA" "0,1"
    GROUP.LONG 0x118++0xe8
        LINE.LONG 0x00 "DMU_HIL_DAT,Hardware in Loop Data"
            BITFLD.LONG 0x00 0.--31. "HIL_DAT    ,HIL_DAT"
    GROUP.LONG 0x200++0x4
        LINE.LONG 0x00 "DMU_MUX_QSPI,IO Mux for QSPI"
            BITFLD.LONG 0x00 0.--2. "MUX_QSPI    ,MUX_QSPI"
    GROUP.LONG 0x204++0x4
        LINE.LONG 0x00 "DMU_MUX_SPI_M1,IO Mux for SPI_M1"
            BITFLD.LONG 0x00 0.--2. "MUX_SPI_M1    ,MUX_SPI_M1"
    GROUP.LONG 0x208++0x4
        LINE.LONG 0x00 "DMU_MUX_UART_0,IO Mux for UART_0"
            BITFLD.LONG 0x00 0.--2. "MUX_UART_0    ,MUX_UART_0"
    GROUP.LONG 0x20C++0x4
        LINE.LONG 0x00 "DMU_MUX_UART_1,IO Mux for UART_1"
            BITFLD.LONG 0x00 0.--2. "MUX_UART_1    ,MUX_UART_1"
    GROUP.LONG 0x210++0x4
        LINE.LONG 0x00 "DMU_MUX_CAN_0,IO Mux for CAN_0"
            BITFLD.LONG 0x00 0.--2. "MUX_CAN_0    ,MUX_CAN_0"
    GROUP.LONG 0x214++0x4
        LINE.LONG 0x00 "DMU_MUX_CAN_1,IO Mux for CAN_1"
            BITFLD.LONG 0x00 0.--2. "MUX_CAN_1    ,MUX_CAN_1"
    GROUP.LONG 0x218++0x4
        LINE.LONG 0x00 "DMU_MUX_RESET,IO Mux for RESET"
            BITFLD.LONG 0x00 0.--2. "MUX_RESET    ,MUX_RESET"
    GROUP.LONG 0x21C++0x4
        LINE.LONG 0x00 "DMU_MUX_SYNC,IO Mux for SYNC"
            BITFLD.LONG 0x00 0.--2. "MUX_SYNC    ,MUX_SYNC"
    GROUP.LONG 0x220++0x4
        LINE.LONG 0x00 "DMU_MUX_I2C_M,IO Mux for I2C_M"
            BITFLD.LONG 0x00 0.--2. "MUX_I2C_M    ,MUX_I2C_M"
    GROUP.LONG 0x224++0x4
        LINE.LONG 0x00 "DMU_MUX_PWM_0,IO Mux for PWM_0"
            BITFLD.LONG 0x00 0.--2. "MUX_PWM_0    ,MUX_PWM_0"
    GROUP.LONG 0x228++0x4
        LINE.LONG 0x00 "DMU_MUX_PWM_1,IO Mux for PWM_1"
            BITFLD.LONG 0x00 0.--2. "MUX_PWM_1    ,MUX_PWM_1"
    GROUP.LONG 0x22C++0x4
        LINE.LONG 0x00 "DMU_MUX_ADC_CLK,IO Mux for ADC_CLK"
            BITFLD.LONG 0x00 0.--2. "MUX_ADC_CLK    ,MUX_ADC_CLK"
    GROUP.LONG 0x230++0x4
        LINE.LONG 0x00 "DMU_MUX_CAN_CLK,IO Mux for CAN_CLK"
            BITFLD.LONG 0x00 0.--2. "MUX_CAN_CLK    ,MUX_CAN_CLK"
    GROUP.LONG 0x234++0x4
        LINE.LONG 0x00 "DMU_MUX_SPI_M0,IO Mux for SPI_M0"
            BITFLD.LONG 0x00 0.--2. "MUX_SPI_M0    ,MUX_SPI_M0"
    GROUP.LONG 0x238++0x4
        LINE.LONG 0x00 "DMU_MUX_SPI_S,IO Mux for SPI_S"
            BITFLD.LONG 0x00 0.--2. "MUX_SPI_S    ,MUX_SPI_S"
    GROUP.LONG 0x23C++0x4
        LINE.LONG 0x00 "DMU_MUX_SPI_S1_CLK,IO Mux for SPI_S1_CLK"
            BITFLD.LONG 0x00 0.--2. "MUX_SPI_S1_CLK    ,MUX_SPI_S1_CLK"
    GROUP.LONG 0x240++0x4
        LINE.LONG 0x00 "DMU_MUX_SPI_S1_SEL,IO Mux for SPI_S1_SEL"
            BITFLD.LONG 0x00 0.--2. "MUX_SPI_S1_SEL    ,MUX_SPI_S1_SEL"
    GROUP.LONG 0x244++0x4
        LINE.LONG 0x00 "DMU_MUX_SPI_S1_MOSI,IO Mux for SPI_S1_MOSI"
            BITFLD.LONG 0x00 0.--2. "MUX_SPI_S1_MOSI    ,MUX_SPI_S1_MOSI"
    GROUP.LONG 0x248++0x4
        LINE.LONG 0x00 "DMU_MUX_SPI_S1_MISO,IO Mux for SPI_S1_MISO"
            BITFLD.LONG 0x00 0.--2. "MUX_SPI_S1_MISO    ,MUX_SPI_S1_MISO"
    GROUP.LONG 0x24C++0xb4
        LINE.LONG 0x00 "DMU_MUX_JTAG,IO Mux for JTAG"
            BITFLD.LONG 0x00 0.--2. "MUX_JTAG    ,MUX_JTAG"
    GROUP.LONG 0x300++0x4
        LINE.LONG 0x00 "DMU_SYS_DMA_ENDIAN,System DMA Endian"
            BITFLD.LONG 0x00 0.--7. "DMA_ENDIAN    ,DMA_ENDIAN"
    GROUP.LONG 0x304++0x4
        LINE.LONG 0x00 "DMU_SYS_SHSEL_NP,System EH2H shsel_np"
            BITFLD.LONG 0x00 0. "SHSEL_NP    ,SHSEL_NP" "0,1"
    GROUP.LONG 0x308++0x4
        LINE.LONG 0x00 "DMU_SYS_DMU_SEL,System IO MUX Select"
            BITFLD.LONG 0x00 0. "DMU_SEL    ,DMU_SEL" "0,1"
    GROUP.LONG 0x30C++0x4
        LINE.LONG 0x00 "DMU_SYS_ICM0_FIX_P,System ICM 0 fix Priority"
            BITFLD.LONG 0x00 0.--5. "ICM0_FIX_P    ,ICM0_FIX_P"
    GROUP.LONG 0x310++0x4
        LINE.LONG 0x00 "DMU_SYS_ICM1_FIX_P,System ICM 1 fix Priority"
            BITFLD.LONG 0x00 0.--5. "ICM1_FIX_P    ,ICM1_FIX_P"
    GROUP.LONG 0x314++0x4
        LINE.LONG 0x00 "DMU_SYS_PWM_ENA,System PWM Enable"
            BITFLD.LONG 0x00 0.--7. "PWM_ENA    ,PWM_ENA"
    GROUP.LONG 0x318++0x4
        LINE.LONG 0x00 "DMU_SYS_MEMRUN_ENA,System MEMRUN  Enable"
            BITFLD.LONG 0x00 0. "MEMRUN_ENA    ,MEMRUN_ENA" "0,1"
    GROUP.LONG 0x31C++0x4
        LINE.LONG 0x00 "DMU_SYS_MEMINI_ENA,System MEMINI  Enable"
            BITFLD.LONG 0x00 0. "MEMINI_ENA    ,MEMINI_ENA" "0,1"
    GROUP.LONG 0x320++0x4
        LINE.LONG 0x00 "DMU_SYS_SPI_LOOP,System SPI Loopback"
            BITFLD.LONG 0x00 0. "SPI_LOOP    ,SPI_LOOP" "0,1"
    GROUP.LONG 0x324++0x4
        LINE.LONG 0x00 "DMU_SYS_OTP_PRGM_EN,System OTP Program Enable"
            BITFLD.LONG 0x00 0. "OTP_PRGM_EN    ,OTP_PRGM_EN" "0,1"
    GROUP.LONG 0x328++0x4
        LINE.LONG 0x00 "DMU_SYS_OTP_ECC_EN,System OTP ECC Enable"
            BITFLD.LONG 0x00 0. "OTP_ECC_EN    ,OTP_ECC_EN" "0,1"
    GROUP.LONG 0x32C++0x4
        LINE.LONG 0x00 "DMU_SYS_MEM_CLR,System Memory Clear"
            BITFLD.LONG 0x00 0. "MEM_CLR    ,MEM_CLR" "0,1"
    GROUP.LONG 0x330++0xd0
        LINE.LONG 0x00 "DMU_SYS_MEM_CLR_DONE,System Memory Clear Done"
            BITFLD.LONG 0x00 0. "MEM_CLR_DONE    ,MEM_CLR_DONE" "0,1"
    GROUP.LONG 0x400++0x4
        LINE.LONG 0x00 "DMU_SW_IRQ_TRIG,CPU Interrupt Trigger"
            BITFLD.LONG 0x00 3. "CPU_IRQ_85_TRIG    ,CPU_IRQ_85_TRIG" "0,1"
            BITFLD.LONG 0x00 2. "CPU_IRQ_84_TRIG    ,CPU_IRQ_84_TRIG" "0,1"
            BITFLD.LONG 0x00 1. "CPU_IRQ_83_TRIG    ,CPU_IRQ_83_TRIG" "0,1"
            BITFLD.LONG 0x00 0. "CPU_IRQ_82_TRIG    ,CPU_IRQ_82_TRIG" "0,1"
            NEWLINE
    GROUP.LONG 0x404++0xfc
        LINE.LONG 0x00 "DMU_SW_IRQ_STA,CPU Interrupt Status"
            BITFLD.LONG 0x00 3. "CPU_IRQ_85_STA    ,CPU_IRQ_85_STA" "0,1"
            BITFLD.LONG 0x00 2. "CPU_IRQ_84_STA    ,CPU_IRQ_84_STA" "0,1"
            BITFLD.LONG 0x00 1. "CPU_IRQ_83_STA    ,CPU_IRQ_83_STA" "0,1"
            BITFLD.LONG 0x00 0. "CPU_IRQ_82_STA    ,CPU_IRQ_82_STA" "0,1"
            NEWLINE
    GROUP.LONG 0x500++0x4
        LINE.LONG 0x00 "DMU_IRQ_ENA_0_31,Interrupt Enable"
            HEXMASK.LONG 0x00 0.--31. "IRQ_ENA_0_32    ,IRQ_ENA_0_32"
    GROUP.LONG 0x504++0x4
        LINE.LONG 0x00 "DMU_IRQ_ENA_32_63,Interrupt Enable"
            HEXMASK.LONG 0x00 0.--31. "IRQ_ENA_32_63    ,IRQ_ENA_32_63"
    GROUP.LONG 0x508++0x4
        LINE.LONG 0x00 "DMU_IRQ_ENA_64_95,Interrupt Enable"
            HEXMASK.LONG 0x00 0.--31. "IRQ_ENA_64_95    ,IRQ_ENA_64_95"
    GROUP.LONG 0x50C++0x4
        LINE.LONG 0x00 "DMU_IRQ_ENA_96_127,Interrupt Enable"
            HEXMASK.LONG 0x00 0.--31. "IRQ_ENA_96_127    ,IRQ_ENA_96_127"
    GROUP.LONG 0x510++0x4
        LINE.LONG 0x00 "DMU_IRQ25_SEL,IRQ25 Select"
            BITFLD.LONG 0x00 0.--7. "IRQ25_SEL    ,IRQ25_SEL"
    GROUP.LONG 0x514++0x4
        LINE.LONG 0x00 "DMU_IRQ26_SEL,IRQ26 Select"
            BITFLD.LONG 0x00 0.--7. "IRQ26_SEL    ,IRQ26_SEL"
    GROUP.LONG 0x518++0x4
        LINE.LONG 0x00 "DMU_IRQ27_SEL,IRQ27 Select"
            BITFLD.LONG 0x00 0.--7. "IRQ27_SEL    ,IRQ27_SEL"
    GROUP.LONG 0x51C++0x4
        LINE.LONG 0x00 "DMU_IRQ28_SEL,IRQ28 Select"
            BITFLD.LONG 0x00 0.--7. "IRQ28_SEL    ,IRQ28_SEL"
    GROUP.LONG 0x520++0x4
        LINE.LONG 0x00 "DMU_IRQ29_SEL,IRQ29 Select"
            BITFLD.LONG 0x00 0.--7. "IRQ29_SEL    ,IRQ29_SEL"
    GROUP.LONG 0x524++0x4
        LINE.LONG 0x00 "DMU_IRQ30_SEL,IRQ30 Select"
            BITFLD.LONG 0x00 0.--7. "IRQ30_SEL    ,IRQ30_SEL"
    GROUP.LONG 0x528++0x03
        LINE.LONG 0x00 "DMU_IRQ31_SEL,IRQ31 Select"
            BITFLD.LONG 0x00 0.--7. "IRQ31_SEL    ,IRQ31_SEL"
TREE.END


TREE "EMU MODULE"
    BASE ad:0xb00000
    GROUP.LONG 0x000++0x4
        LINE.LONG 0x00 "EMU_SOP,SOP status"
            HEXMASK.LONG 0x00 6.--31. "SOP_SPARED    ,SOP_SPARED"
            BITFLD.LONG 0x00 5. "SOP_DEBUG    ,SOP_DEBUG" "0,1"
            BITFLD.LONG 0x00 2.--4. "SOP_BOOT    ,SOP_BOOT"
            BITFLD.LONG 0x00 0.--1. "SOP_FSM    ,SOP_FSM" "0,1,2,3"
            NEWLINE
    GROUP.LONG 0x004++0x4
        LINE.LONG 0x00 "EMU_SEC_STA,OTP Security Status"
            BITFLD.LONG 0x00 1. "OTP_JD    ,OTP_JD" "0,1"
            BITFLD.LONG 0x00 0. "OTP_SE    ,OTP_SE" "0,1"
    GROUP.LONG 0x008++0x4
        LINE.LONG 0x00 "EMU_SEC_CTRL,Security Control"
            BITFLD.LONG 0x00 1. "EMU_JD    ,EMU_JD" "0,1"
            BITFLD.LONG 0x00 0. "EMU_SE    ,EMU_SE" "0,1"
    GROUP.LONG 0x00C++0x4
        LINE.LONG 0x00 "EMU_SAFETY_PAD_CTRL,Safety Pad Output Control"
            BITFLD.LONG 0x00 0. "SAFETY_PAD_CTRL    ,SAFETY_PAD_CTRL" "0,1"
    GROUP.LONG 0x010++0x4
        LINE.LONG 0x00 "EMU_SAFETY_KEY1,Safety Pad Key 1"
            BITFLD.LONG 0x00 0.--31. "SAFETY_KEY1    ,SAFETY_KEY1"
    GROUP.LONG 0x014++0x4
        LINE.LONG 0x00 "EMU_SAFETY_KEY2,Safety Pad Key 2"
            BITFLD.LONG 0x00 0.--31. "SAFETY_KEY2    ,SAFETY_KEY2"
    GROUP.LONG 0x018++0x4
        LINE.LONG 0x00 "EMU_ERROR_OUT_O,ERROR_OUT Pad Output Value"
            BITFLD.LONG 0x00 0. "ERROR_OUT_O    ,ERROR_OUT_O" "0,1"
    GROUP.LONG 0x01C++0xe4
        LINE.LONG 0x00 "EMU_SAFE_STATE_O,SAFE_STATE Pad Output Value"
            BITFLD.LONG 0x00 0. "SAFE_STATE_O    ,SAFE_STATE_O" "0,1"
    GROUP.LONG 0x100++0x4
        LINE.LONG 0x00 "EMU_FSM_STA,FSM status"
            BITFLD.LONG 0x00 0.--7. "FSM_CS    ,FSM_CS"
    GROUP.LONG 0x104++0x4
        LINE.LONG 0x00 "EMU_WDT_ENA,WatchDog Timer Enable"
            BITFLD.LONG 0x00 0. "WDT_ENA    ,WDT_ENA" "0,1"
    GROUP.LONG 0x108++0x4
        LINE.LONG 0x00 "EMU_WDT_RELOAD,WatchDog Timer Reload"
            BITFLD.LONG 0x00 0. "WDT_RELOAD    ,WDT_RELOAD" "0,1"
    GROUP.LONG 0x10C++0x4
        LINE.LONG 0x00 "EMU_WDT_INIT,WatchDog Timer Initial Value"
            HEXMASK.LONG 0x00 0.--31. "WDT_INIT    ,WDT_INIT"
    GROUP.LONG 0x110++0x4
        LINE.LONG 0x00 "EMU_WDT_VAL,WatchDog Timer Value"
            HEXMASK.LONG 0x00 0.--31. "WDT_VAL    ,WDT_VAL"
    GROUP.LONG 0x114++0x4
        LINE.LONG 0x00 "EMU_BOOT_DONE,Boot State Done"
            BITFLD.LONG 0x00 0. "BOOT_DONE    ,BOOT_DONE" "0,1"
    GROUP.LONG 0x118++0xe8
        LINE.LONG 0x00 "EMU_SS1_CTRL,SS1 State Control"
            BITFLD.LONG 0x00 0. "SS1_CTRL    ,SS1_CTRL" "0,1"
    GROUP.LONG 0x200++0x4
        LINE.LONG 0x00 "EMU_MBIST_CLK_ENA,MBIST Clock Enable"
            BITFLD.LONG 0x00 0. "MBIST_CLK_ENA    ,MBIST_CLK_ENA" "0,1"
    GROUP.LONG 0x204++0x4
        LINE.LONG 0x00 "EMU_GLBIST_CLK_ENA,Global LBIST Clock Enable"
            BITFLD.LONG 0x00 0. "GLBIST_CLK_ENA    ,GLBIST_CLK_ENA" "0,1"
    GROUP.LONG 0x208++0x4
        LINE.LONG 0x00 "EMU_BB_LBIST_CLK_ENA,BB LBIST Clock Enable"
            BITFLD.LONG 0x00 0. "BB_LBIST_CLK_ENA    ,BB_LBIST_CLK_ENA" "0,1"
    GROUP.LONG 0x20C++0x4
        LINE.LONG 0x00 "EMU_BB_LBIST_MODE,BB LBIST Mode"
            BITFLD.LONG 0x00 0. "GLBIST_MODE    ,GLBIST_MODE" "0,1"
    GROUP.LONG 0x210++0x4
        LINE.LONG 0x00 "EMU_BB_LBIST_ENA,BB LBIST Enable"
            BITFLD.LONG 0x00 0. "BB_LBIST_ENA    ,BB_LBIST_ENA" "0,1"
    GROUP.LONG 0x214++0xec
        LINE.LONG 0x00 "EMU_BB_LBIST_CLR,BB LBIST Clear"
            BITFLD.LONG 0x00 0. "BB_LBIST_CLR    ,BB_LBIST_CLR" "0,1"
    GROUP.LONG 0x300++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_IRQ_ENA,RF Test Interrupt Enable"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_IRQ_ENA    ,RF_ERR_IRQ_ENA"
    GROUP.LONG 0x304++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_IRQ_STA,RF Test Interrupt Status"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_IRQ_STA    ,RF_ERR_IRQ_STA"
    GROUP.LONG 0x308++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_IRQ_MARK,RF Test Interrupt Mark"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_IRQ_MARK    ,RF_ERR_IRQ_MARK"
    GROUP.LONG 0x30C++0x4
        LINE.LONG 0x00 "EMU_RF_EER_SS1_ENA,RF Test SS1 Enable"
            BITFLD.LONG 0x00 0.--12. "RF_EER_SS1_ENA    ,RF_EER_SS1_ENA"
    GROUP.LONG 0x310++0x4
        LINE.LONG 0x00 "EMU_RF_EER_SS1_STA,RF Test SS1 Status"
            BITFLD.LONG 0x00 0.--12. "RF_EER_SS1_STA    ,RF_EER_SS1_STA"
    GROUP.LONG 0x314++0x4
        LINE.LONG 0x00 "EMU_RF_EER_SS1_MARK,RF Test SS1 Mark"
            BITFLD.LONG 0x00 0.--12. "RF_EER_SS1_MARK    ,RF_EER_SS1_MARK"
    GROUP.LONG 0x318++0x4
        LINE.LONG 0x00 "EMU_RF_EER_SS2_ENA,RF Test SS2 Enable"
            BITFLD.LONG 0x00 0.--12. "RF_EER_SS2_ENA    ,RF_EER_SS2_ENA"
    GROUP.LONG 0x31C++0x4
        LINE.LONG 0x00 "EMU_RF_EER_SS2_STA,RF Test SS2 Status"
            BITFLD.LONG 0x00 0.--12. "RF_EER_SS2_STA    ,RF_EER_SS2_STA"
    GROUP.LONG 0x320++0x4
        LINE.LONG 0x00 "EMU_RF_EER_SS2_MARK,RF Test SS2 Mark"
            BITFLD.LONG 0x00 0.--12. "RF_EER_SS2_MARK    ,RF_EER_SS2_MARK"
    GROUP.LONG 0x324++0x4
        LINE.LONG 0x00 "EMU_RF_TEST_ENA,RF Test Enable"
            BITFLD.LONG 0x00 0.--12. "RF_TEST_ENA    ,RF_TEST_ENA"
    GROUP.LONG 0x328++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_CLR,RF Error Clear"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_CLR    ,RF_ERR_CLR"
    GROUP.LONG 0x32C++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_STA,RF Error Status"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_STA    ,RF_ERR_STA"
    GROUP.LONG 0x330++0xd0
        LINE.LONG 0x00 "EMU_RF_TEST_DIV,RF Test Divider"
            BITFLD.LONG 0x00 0.--15. "RF_TEST_DIV    ,RF_TEST_DIV"
    GROUP.LONG 0x400++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_IRQ_ENA,Digital Test Interrupt Enable"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_IRQ_ENA    ,DIG_ERR_IRQ_ENA"
    GROUP.LONG 0x404++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_IRQ_STA,Digital Test Interrupt Status"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_IRQ_STA    ,DIG_ERR_IRQ_STA"
    GROUP.LONG 0x408++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_IRQ_MARK,Digital Test Interrupt Mark"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_IRQ_MARK    ,DIG_ERR_IRQ_MARK"
    GROUP.LONG 0x40C++0x4
        LINE.LONG 0x00 "EMU_DIG_EER_SS1_ENA,Digital Test SS1 Enable"
            BITFLD.LONG 0x00 0.--20. "DIG_EER_SS1_ENA    ,DIG_EER_SS1_ENA"
    GROUP.LONG 0x410++0x4
        LINE.LONG 0x00 "EMU_DIG_EER_SS1_STA,Digital Test SS1 Status"
            BITFLD.LONG 0x00 0.--20. "DIG_EER_SS1_STA    ,DIG_EER_SS1_STA"
    GROUP.LONG 0x414++0x4
        LINE.LONG 0x00 "EMU_DIG_EER_SS1_MARK,Digital Test SS1 Mark"
            BITFLD.LONG 0x00 0.--20. "DIG_EER_SS1_MARK    ,DIG_EER_SS1_MARK"
    GROUP.LONG 0x418++0x4
        LINE.LONG 0x00 "EMU_DIG_EER_SS2_ENA,Digital Test SS2 Enable"
            BITFLD.LONG 0x00 0.--20. "DIG_EER_SS2_ENA    ,DIG_EER_SS2_ENA"
    GROUP.LONG 0x41C++0x4
        LINE.LONG 0x00 "EMU_DIG_EER_SS2_STA,Digital Test SS2 Status"
            BITFLD.LONG 0x00 0.--20. "DIG_EER_SS2_STA    ,DIG_EER_SS2_STA"
    GROUP.LONG 0x420++0x4
        LINE.LONG 0x00 "EMU_DIG_EER_SS2_MARK,Digital Test SS2 Mark"
            BITFLD.LONG 0x00 0.--20. "DIG_EER_SS2_MARK    ,DIG_EER_SS2_MARK"
    GROUP.LONG 0x424++0x4
        LINE.LONG 0x00 "EMU_DIG_TEST_ENA,Digital Test Enable"
            BITFLD.LONG 0x00 0.--20. "DIG_TEST_ENA    ,DIG_TEST_ENA"
    GROUP.LONG 0x428++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_CLR,Digital Error Clear"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_CLR    ,DIG_ERR_CLR"
    GROUP.LONG 0x42C++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_STA,Digital Error Status"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_STA    ,DIG_ERR_STA"
    GROUP.LONG 0x430++0xd0
        LINE.LONG 0x00 "EMU_DIG_TEST_DIV,Digital Test Divider"
            BITFLD.LONG 0x00 0.--15. "DIG_TEST_DIV    ,DIG_TEST_DIV"
    GROUP.LONG 0x500++0x4
        LINE.LONG 0x00 "EMU_MBIST_STA,MBIST Status"
            BITFLD.LONG 0x00 1. "MBIST_FAIL    ,MBIST_FAIL" "0,1"
            BITFLD.LONG 0x00 0. "MBIST_DONE    ,MBIST_DONE" "0,1"
    GROUP.LONG 0x504++0x4
        LINE.LONG 0x00 "EMU_LBIST_STA,LBIST Status"
            BITFLD.LONG 0x00 3. "GLBIST_FAIL    ,GLBIST_FAIL" "0,1"
            BITFLD.LONG 0x00 2. "GLBIST_DONE    ,GLBIST_DONE" "0,1"
            BITFLD.LONG 0x00 1. "BB_LBIST_FAIL    ,BB_LBIST_FAIL" "0,1"
            BITFLD.LONG 0x00 0. "BB_LBIST_DONE    ,BB_LBIST_DONE" "0,1"
            NEWLINE
    GROUP.LONG 0x508++0x4
        LINE.LONG 0x00 "EMU_BOOT_STA,Boot Status"
            BITFLD.LONG 0x00 1. "BOOT_FAIL    ,BOOT_FAIL" "0,1"
            BITFLD.LONG 0x00 0. "BOOT_DONE    ,BOOT_DONE" "0,1"
    GROUP.LONG 0x50C++0x4
        LINE.LONG 0x00 "EMU_REBOOT_CNT,Reboot Counter"
            BITFLD.LONG 0x00 0.--31. "REBOOT_CNT    ,REBOOT_CNT"
    GROUP.LONG 0x510++0x4
        LINE.LONG 0x00 "EMU_REBOOT_LIMIT,Reboot Limit"
            BITFLD.LONG 0x00 2. "REBOOT_LIMIT_DIS    ,REBOOT_LIMIT_DIS" "0,1"
            BITFLD.LONG 0x00 0.--1. "REBOOT_LIMIT_NUM    ,REBOOT_LIMIT_NUM" "0,1,2,3"
    GROUP.LONG 0x514++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_SS1_CODE_0,RF SS1 Error Code 0"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_SS1_CODE_0    ,RF_ERR_SS1_CODE_0"
    GROUP.LONG 0x518++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_SS1_CODE_1,RF SS1 Error Code 1"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_SS1_CODE_1    ,RF_ERR_SS1_CODE_1"
    GROUP.LONG 0x51C++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_SS1_CODE_2,RF SS1 Error Code 2"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_SS1_CODE_2    ,RF_ERR_SS1_CODE_2"
    GROUP.LONG 0x520++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_SS1_CODE_3,RF SS1 Error Code 3"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_SS1_CODE_3    ,RF_ERR_SS1_CODE_3"
    GROUP.LONG 0x524++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_SS1_CODE_0,Digital SS1 Error Code 0"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_SS1_CODE_0    ,DIG_ERR_SS1_CODE_0"
    GROUP.LONG 0x528++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_SS1_CODE_1,Digital SS1 Error Code 1"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_SS1_CODE_1    ,DIG_ERR_SS1_CODE_1"
    GROUP.LONG 0x52C++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_SS1_CODE_2,Digital SS1 Error Code 2"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_SS1_CODE_2    ,DIG_ERR_SS1_CODE_2"
    GROUP.LONG 0x530++0x4
        LINE.LONG 0x00 "EMU_DIG_ERR_SS1_CODE_3,Digital SS1 Error Code 3"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_SS1_CODE_3    ,DIG_ERR_SS1_CODE_3"
    GROUP.LONG 0x534++0x4
        LINE.LONG 0x00 "EMU_RF_ERR_SS2_CODE,RF SS2 Error Code"
            BITFLD.LONG 0x00 0.--12. "RF_ERR_SS2_CODE    ,RF_ERR_SS2_CODE"
    GROUP.LONG 0x538++0xc8
        LINE.LONG 0x00 "EMU_DIG_ERR_SS2_CODE,Digital SS2 Error Code"
            BITFLD.LONG 0x00 0.--20. "DIG_ERR_SS2_CODE    ,DIG_ERR_SS2_CODE"
    GROUP.LONG 0x600++0x4
        LINE.LONG 0x00 "EMU_SPARED_0,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_0    ,SPARED_0"
    GROUP.LONG 0x604++0x4
        LINE.LONG 0x00 "EMU_SPARED_1,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_1    ,SPARED_1"
    GROUP.LONG 0x608++0x4
        LINE.LONG 0x00 "EMU_SPARED_2,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_2    ,SPARED_2"
    GROUP.LONG 0x60C++0x4
        LINE.LONG 0x00 "EMU_SPARED_3,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_3    ,SPARED_3"
    GROUP.LONG 0x610++0x4
        LINE.LONG 0x00 "EMU_SPARED_4,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_4    ,SPARED_4"
    GROUP.LONG 0x614++0x4
        LINE.LONG 0x00 "EMU_SPARED_5,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_5    ,SPARED_5"
    GROUP.LONG 0x618++0x4
        LINE.LONG 0x00 "EMU_SPARED_6,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_6    ,SPARED_6"
    GROUP.LONG 0x61C++0x4
        LINE.LONG 0x00 "EMU_SPARED_7,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_7    ,SPARED_7"
    GROUP.LONG 0x620++0x4
        LINE.LONG 0x00 "EMU_SPARED_8,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_8    ,SPARED_8"
    GROUP.LONG 0x624++0x4
        LINE.LONG 0x00 "EMU_SPARED_9,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_9    ,SPARED_9"
    GROUP.LONG 0x628++0x4
        LINE.LONG 0x00 "EMU_SPARED_10,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_10    ,SPARED_10"
    GROUP.LONG 0x62C++0x4
        LINE.LONG 0x00 "EMU_SPARED_11,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_11    ,SPARED_11"
    GROUP.LONG 0x630++0x4
        LINE.LONG 0x00 "EMU_SPARED_12,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_12    ,SPARED_12"
    GROUP.LONG 0x634++0x4
        LINE.LONG 0x00 "EMU_SPARED_13,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_13    ,SPARED_13"
    GROUP.LONG 0x638++0x4
        LINE.LONG 0x00 "EMU_SPARED_14,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_14    ,SPARED_14"
    GROUP.LONG 0x63C++0x03
        LINE.LONG 0x00 "EMU_SPARED_15,Spared Register"
            BITFLD.LONG 0x00 0.--31. "SPARED_15    ,SPARED_15"
TREE.END

TREE "BB MODULE"
    BASE ad:0xE00000
	GROUP.LONG 0x0000++0x03
        LINE.LONG 0x00 "CTL_SYS_START,start bit for baseband"
    GROUP.LONG 0x0004++0x03
        LINE.LONG 0x00 "CFG_SYS_BNK_MODE,working mode of banks"
    GROUP.LONG 0x0008++0x03
        LINE.LONG 0x00 "CFG_SYS_BNK_ACT,active bank for APB access"
    GROUP.LONG 0x000C++0x03
        LINE.LONG 0x00 "CFG_SYS_BNK_QUE,enabled banks in rotate and multi mode"
    GROUP.LONG 0x0010++0x03
        LINE.LONG 0x00 "CTL_SYS_BNK_RST,reset for bank mode"
    GROUP.LONG 0x0014++0x03
        LINE.LONG 0x00 "CFG_SYS_MEM_ACT,active memory for CPU access"
    GROUP.LONG 0x0018++0x03
        LINE.LONG 0x00 "CFG_SYS_ENABLE,enable bits for sub-function"
    GROUP.LONG 0x001C++0x03
        LINE.LONG 0x00 "CFG_SYS_TYPE_FMCW,CFG_SYS_TYPE_FMCW"
    GROUP.LONG 0x0020++0x03
        LINE.LONG 0x00 "CFG_SYS_SIZE_RNG_PRD,chirp length"
    GROUP.LONG 0x0024++0x03
        LINE.LONG 0x00 "CFG_SYS_SIZE_FLT,CFG_SYS_SIZE_FLT"
    GROUP.LONG 0x0028++0x03
        LINE.LONG 0x00 "CFG_SYS_SIZE_RNG_SKP,skip length"
    GROUP.LONG 0x002C++0x03
        LINE.LONG 0x00 "CFG_SYS_SIZE_RNG_BUF,buffer length"
    GROUP.LONG 0x0030++0x03
        LINE.LONG 0x00 "CFG_SYS_SIZE_RNG_FFT,1st FFT length"
    GROUP.LONG 0x0034++0x03
        LINE.LONG 0x00 "CFG_SYS_SIZE_BPM,BPM size"
    GROUP.LONG 0x0038++0x03
        LINE.LONG 0x00 "CFG_SYS_SIZE_VEL_BUF,chirp number"
    GROUP.LONG 0x003C++0x03
        LINE.LONG 0x00 "CFG_SYS_SIZE_VEL_FFT,2nd FFT length"
    GROUP.LONG 0x0040++0x03
        LINE.LONG 0x00 "CFG_SYS_FRMT_ADC,CFG_SYS_FRMT_ADC"
    GROUP.LONG 0x0044++0x03
        LINE.LONG 0x00 "CFG_SYS_IRQ_ENA,enable bits for IRQ"
    GROUP.LONG 0x0048++0x03
        LINE.LONG 0x00 "CTL_SYS_IRQ_CLR,clear bits for IRQ"
    GROUP.LONG 0x004C++0x03
        LINE.LONG 0x00 "CFG_SYS_ECC_ENA,enable bits for ECC"
    GROUP.LONG 0x0050++0x03
        LINE.LONG 0x00 "CTL_SYS_ECC_SB_CLR,clear bits for ECC (single-bit error)"
    GROUP.LONG 0x0054++0x03
        LINE.LONG 0x00 "CTL_SYS_ECC_DB_CLR,clear bits for ECC (double-bit error)"
    GROUP.LONG 0x0058++0x03
        LINE.LONG 0x00 "CFG_SYS_TYP_ARB,CFG_SYS_TYP_ARB"
    GROUP.LONG 0x005C++0x03
        LINE.LONG 0x00 "FDB_SYS_STATUS,current status of baseband"
    GROUP.LONG 0x0060++0x03
        LINE.LONG 0x00 "FDB_SYS_BNK_ACT,current active bank of baseband"
    GROUP.LONG 0x0064++0x03
        LINE.LONG 0x00 "FDB_SYS_IRQ_STATUS,current status of irq"
    GROUP.LONG 0x0068++0x03
        LINE.LONG 0x00 "FDB_SYS_ECC_SB_STATUS,current status of ECC (single-bit error)"
    GROUP.LONG 0x006C++0x03
        LINE.LONG 0x00 "FDB_SYS_ECC_DB_STATUS,current status of ECC (double-bit error)"
    GROUP.LONG 0x0200++0x03
        LINE.LONG 0x00 "CFG_AGC_SAT_THR_TIA_,threshold for saturation decision of TIA"
    GROUP.LONG 0x0204++0x03
        LINE.LONG 0x00 "CFG_AGC_SAT_THR_VGA1,threshold for saturation decision of VGA1"
    GROUP.LONG 0x0208++0x03
        LINE.LONG 0x00 "CFG_AGC_SAT_THR_VGA2,threshold for saturation decision of VGA2"
    GROUP.LONG 0x020C++0x03
        LINE.LONG 0x00 "CTL_AGC_SAT_CNT_CLR_FRA,clear frame counter for saturation indicator"
    GROUP.LONG 0x0210++0x03
        LINE.LONG 0x00 "CFG_AGC_DAT_MAX_SEL,selection bits for ADC data used to estimate ADC power"
    GROUP.LONG 0x0214++0x03
        LINE.LONG 0x00 "CFG_AGC_CODE_LNA_0,RF bits for level 0 of LNA"
    GROUP.LONG 0x0218++0x03
        LINE.LONG 0x00 "CFG_AGC_CODE_LNA_1,RF bits for level 1 of LNA"
    GROUP.LONG 0x021C++0x03
        LINE.LONG 0x00 "CFG_AGC_CODE_TIA_0,RF bits for level 0 of TIA"
    GROUP.LONG 0x0220++0x03
        LINE.LONG 0x00 "CFG_AGC_CODE_TIA_1,RF bits for level 1 of TIA"
    GROUP.LONG 0x0224++0x03
        LINE.LONG 0x00 "CFG_AGC_CODE_TIA_2,RF bits for level 2 of TIA"
    GROUP.LONG 0x0228++0x03
        LINE.LONG 0x00 "CFG_AGC_CODE_TIA_3,RF bits for level 3 of TIA"
    GROUP.LONG 0x022C++0x03
        LINE.LONG 0x00 "CFG_AGC_GAIN_MIN,minimum gain of LNA, TIA, VGA1, VGA2"
    GROUP.LONG 0x0230++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_INIT,initial setting and the corresponding gain"
    GROUP.LONG 0x0234++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C0_0,setting 0-0"
    GROUP.LONG 0x0238++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C0_1,setting 0-0"
    GROUP.LONG 0x023C++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C0_2,setting 0-1"
    GROUP.LONG 0x0240++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_0,setting 1-0"
    GROUP.LONG 0x0244++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_1,setting 1-1"
    GROUP.LONG 0x0248++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_2,setting 1-2"
    GROUP.LONG 0x024C++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_3,setting 1-3"
    GROUP.LONG 0x0250++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_4,setting 1-4"
    GROUP.LONG 0x0254++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_5,setting 1-5"
    GROUP.LONG 0x0258++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_6,setting 1-6"
    GROUP.LONG 0x025C++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_7,setting 1-7"
    GROUP.LONG 0x0260++0x03
        LINE.LONG 0x00 "CFG_AGC_CDGN_C1_8,setting 1-8"
    GROUP.LONG 0x0264++0x03
        LINE.LONG 0x00 "CFG_AGC_CHCK_ENA,enable bit for check adc buffer saturation"
    GROUP.LONG 0x0268++0x03
        LINE.LONG 0x00 "CFG_AGC_ALIGN_EN,enable bit for aligning agc of  4 channels"
    GROUP.LONG 0x026C++0x03
        LINE.LONG 0x00 "CFG_AGC_CMPN_EN,enable bit for agc compensation"
    GROUP.LONG 0x0270++0x03
        LINE.LONG 0x00 "CFG_AGC_CMPN_ALIGN_EN,enable bit for aligning agc compensation of 4 channels"
    GROUP.LONG 0x0274++0x03
        LINE.LONG 0x00 "CFG_AGC_CMPN_LVL,agc compensation reference level"
    GROUP.LONG 0x0278++0x03
        LINE.LONG 0x00 "CFG_AGC_DB_TARGET,agc target power value(DB)"
    GROUP.LONG 0x027C++0x03
        LINE.LONG 0x00 "CFG_AGC_IRQ_ENA,enable bits for irq"
    GROUP.LONG 0x0280++0x03
        LINE.LONG 0x00 "CTL_AGC_IRQ_CLR,clear irq status"
    GROUP.LONG 0x0284++0x03
        LINE.LONG 0x00 "FDB_AGC_COD_C0,current setting of LNA, TIA, VGA1 & VGA2 in channel 0"
    GROUP.LONG 0x0288++0x03
        LINE.LONG 0x00 "FDB_AGC_COD_C1,current setting of LNA, TIA, VGA1 & VGA2 in channel 1"
    GROUP.LONG 0x028C++0x03
        LINE.LONG 0x00 "FDB_AGC_COD_C2,current setting of LNA, TIA, VGA1 & VGA2 in channel 2"
    GROUP.LONG 0x0290++0x03
        LINE.LONG 0x00 "FDB_AGC_COD_C3,current setting of LNA, TIA, VGA1 & VGA2 in channel 3"
    GROUP.LONG 0x0294++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_TIA__C0,counter for saturation indicator of TIA in channel 0"
    GROUP.LONG 0x0298++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_TIA__C1,counter for saturation indicator of TIA in channel 1"
    GROUP.LONG 0x029C++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_TIA__C2,counter for saturation indicator of TIA in channel 2"
    GROUP.LONG 0x02A0++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_TIA__C3,counter for saturation indicator of TIA in channel 3"
    GROUP.LONG 0x02A4++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_VGA1_C0,counter for saturation indicator of VGA1 in channel 0"
    GROUP.LONG 0x02A8++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_VGA1_C1,counter for saturation indicator of VGA1 in channel 1"
    GROUP.LONG 0x02AC++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_VGA1_C2,counter for saturation indicator of VGA1 in channel 2"
    GROUP.LONG 0x02B0++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_VGA1_C3,counter for saturation indicator of VGA1 in channel 3"
    GROUP.LONG 0x02B4++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_VGA2_C0,counter for saturation indicator of VGA2 in channel 0"
    GROUP.LONG 0x02B8++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_VGA2_C1,counter for saturation indicator of VGA2 in channel 1"
    GROUP.LONG 0x02BC++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_VGA2_C2,counter for saturation indicator of VGA2 in channel 2"
    GROUP.LONG 0x02C0++0x03
        LINE.LONG 0x00 "FDB_AGC_SAT_CNT_VGA2_C3,counter for saturation indicator of VGA2 in channel 3"
    GROUP.LONG 0x02C4++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_1ST_C0,1st maximum absolute value of ADC data in channel 0"
    GROUP.LONG 0x02C8++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_1ST_C1,1st maximum absolute value of ADC data in channel 1"
    GROUP.LONG 0x02CC++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_1ST_C2,1st maximum absolute value of ADC data in channel 2"
    GROUP.LONG 0x02D0++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_1ST_C3,1st maximum absolute value of ADC data in channel 3"
    GROUP.LONG 0x02D4++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_2ND_C0,2nd maximum absolute value of ADC data in channel 0"
    GROUP.LONG 0x02D8++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_2ND_C1,2nd maximum absolute value of ADC data in channel 1"
    GROUP.LONG 0x02DC++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_2ND_C2,2nd maximum absolute value of ADC data in channel 2"
    GROUP.LONG 0x02E0++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_2ND_C3,2nd maximum absolute value of ADC data in channel 3"
    GROUP.LONG 0x02E4++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_3RD_C0,3rd maximum absolute value of ADC data in channel 0"
    GROUP.LONG 0x02E8++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_3RD_C1,3rd maximum absolute value of ADC data in channel 1"
    GROUP.LONG 0x02EC++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_3RD_C2,3rd maximum absolute value of ADC data in channel 2"
    GROUP.LONG 0x02F0++0x03
        LINE.LONG 0x00 "FDB_AGC_DAT_MAX_3RD_C3,3rd maximum absolute value of ADC data in channel 3"
    GROUP.LONG 0x02F4++0x03
        LINE.LONG 0x00 "FDB_AGC_IRQ_STATUS,agc irq status"
    GROUP.LONG 0x0400++0x03
        LINE.LONG 0x00 "CFG_SAM_SINKER,selection bit for sinker of module SAM"
    GROUP.LONG 0x0404++0x03
        LINE.LONG 0x00 "CFG_SAM_F_0_S1,shifter in stage 0"
    GROUP.LONG 0x0408++0x03
        LINE.LONG 0x00 "CFG_SAM_F_0_B1,coefficient b1 in stage 0"
    GROUP.LONG 0x040C++0x03
        LINE.LONG 0x00 "CFG_SAM_F_0_A1,coefficient a1 in stage 0"
    GROUP.LONG 0x0410++0x03
        LINE.LONG 0x00 "CFG_SAM_F_0_A2,coefficient a2 in stage 0"
    GROUP.LONG 0x0414++0x03
        LINE.LONG 0x00 "CFG_SAM_F_1_S1,shifter in stage 1"
    GROUP.LONG 0x0418++0x03
        LINE.LONG 0x00 "CFG_SAM_F_1_B1,coefficient b1 in stage 1"
    GROUP.LONG 0x041C++0x03
        LINE.LONG 0x00 "CFG_SAM_F_1_A1,coefficient a1 in stage 1"
    GROUP.LONG 0x0420++0x03
        LINE.LONG 0x00 "CFG_SAM_F_1_A2,coefficient a2 in stage 1"
    GROUP.LONG 0x0424++0x03
        LINE.LONG 0x00 "CFG_SAM_F_2_S1,shifter in stage 2"
    GROUP.LONG 0x0428++0x03
        LINE.LONG 0x00 "CFG_SAM_F_2_B1,coefficient b1 in stage 2"
    GROUP.LONG 0x042C++0x03
        LINE.LONG 0x00 "CFG_SAM_F_2_A1,coefficient a1 in stage 2"
    GROUP.LONG 0x0430++0x03
        LINE.LONG 0x00 "CFG_SAM_F_2_A2,coefficient a2 in stage 2"
    GROUP.LONG 0x0434++0x03
        LINE.LONG 0x00 "CFG_SAM_F_3_S1,shifter in stage 3"
    GROUP.LONG 0x0438++0x03
        LINE.LONG 0x00 "CFG_SAM_F_3_B1,coefficient b1 in stage 3"
    GROUP.LONG 0x043C++0x03
        LINE.LONG 0x00 "CFG_SAM_F_3_A1,coefficient a1 in stage 3"
    GROUP.LONG 0x0440++0x03
        LINE.LONG 0x00 "CFG_SAM_F_3_A2,coefficient a2 in stage 3"
    GROUP.LONG 0x0444++0x03
        LINE.LONG 0x00 "CFG_SAM_FNL_SHF,shifter in final stage"
    GROUP.LONG 0x0448++0x03
        LINE.LONG 0x00 "CFG_SAM_FNL_SCL,coefficient in final stage"
    GROUP.LONG 0x044C++0x03
        LINE.LONG 0x00 "CFG_SAM_DINT_ENA,enable bit for de-interference"
    GROUP.LONG 0x0450++0x03
        LINE.LONG 0x00 "CFG_SAM_DINT_MOD,host control or manual control"
    GROUP.LONG 0x0454++0x03
        LINE.LONG 0x00 "CTL_SAM_DINT_SET,reinitialize CFG_SAM_DINT_DAT for de-interference XOR chain"
    GROUP.LONG 0x0458++0x03
        LINE.LONG 0x00 "CFG_SAM_DINT_DAT,initial data for de-interference XOR chain"
    GROUP.LONG 0x045C++0x03
        LINE.LONG 0x00 "CFG_SAM_DINT_MSK,tapper for de-interference XOR chain"
    GROUP.LONG 0x0460++0x03
        LINE.LONG 0x00 "CFG_SAM_DAMB_PRD,chirp length of de-ambiguity"
    GROUP.LONG 0x0464++0x03
        LINE.LONG 0x00 "CFG_SAM_FORCE,force start bit for module SAM"
    GROUP.LONG 0x0468++0x03
        LINE.LONG 0x00 "CFG_SAM_DBG_SRC,selection bits for debug data in module SAM"
    GROUP.LONG 0x046C++0x03
        LINE.LONG 0x00 "CFG_SAM_SIZE_DBG_BGN,start position to dump debug data in each chirp"
    GROUP.LONG 0x0470++0x03
        LINE.LONG 0x00 "CFG_SAM_SIZE_DBG_END,stop position to dump debug data in each chirp"
    GROUP.LONG 0x0474++0x03
        LINE.LONG 0x00 "CFG_SAM_SPK_RM_EN,enable removing or smoothing ADC spike samples caused by interference radar"
    GROUP.LONG 0x0478++0x03
        LINE.LONG 0x00 "CFG_SAM_SPK_CFM_SIZE,buffer length for internal algorithm used to decide whether a sample is an  interference spike "
    GROUP.LONG 0x047C++0x03
        LINE.LONG 0x00 "CFG_SAM_SPK_SET_ZERO,enable setting interference spike samples to zero"
    GROUP.LONG 0x0480++0x03
        LINE.LONG 0x00 "CFG_SAM_SPK_OVER_NUM,1) Higher 2 bits represent the most number of overflow spike samples in overflow free region"
    GROUP.LONG 0x0484++0x03
        LINE.LONG 0x00 "CFG_SAM_SPK_THRES_DBL,enable doubling the threshold value for deciding whether a sample is an interference spike"
    GROUP.LONG 0x0488++0x03
        LINE.LONG 0x00 "CFG_SAM_SPK_MIN_MAX_SEL,enable choosing the smaller maximum difference estimated in a chirp as the final one"
    GROUP.LONG 0x048C++0x03
        LINE.LONG 0x00 "FDB_SAM_DINT_DAT,initial data for de-interference XOR chain"
    GROUP.LONG 0x0600++0x03
        LINE.LONG 0x00 "CFG_FFT_SHFT_RNG,CFG_FFT_SHFT_RNG"
    GROUP.LONG 0x0604++0x03
        LINE.LONG 0x00 "CFG_FFT_SHFT_VEL,CFG_FFT_SHFT_VEL"
    GROUP.LONG 0x0608++0x03
        LINE.LONG 0x00 "CFG_FFT_DBPM_ENA,CFG_FFT_DBPM_ENA"
    GROUP.LONG 0x060C++0x03
        LINE.LONG 0x00 "CFG_FFT_DBPM_DIR,CFG_FFT_DBPM_DIR"
    GROUP.LONG 0x0610++0x03
        LINE.LONG 0x00 "CFG_FFT_DAMB_ENA,CFG_FFT_DAMB_ENA"
    GROUP.LONG 0x0614++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_ENA,CFG_FFT_DINT_ENA"
    GROUP.LONG 0x0618++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_MOD,CFG_FFT_DINT_MOD"
    GROUP.LONG 0x061C++0x03
        LINE.LONG 0x00 "CTL_FFT_DINT_SET,CTL_FFT_DINT_SET"
    GROUP.LONG 0x0620++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_DAT_FH,CFG_FFT_DINT_DAT_FH"
    GROUP.LONG 0x0624++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_DAT_CS,CFG_FFT_DINT_DAT_CS"
    GROUP.LONG 0x0628++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_DAT_PS,CFG_FFT_DINT_DAT_PS"
    GROUP.LONG 0x062C++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_MSK_FH,CFG_FFT_DINT_MSK_FH"
    GROUP.LONG 0x0630++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_MSK_CS,CFG_FFT_DINT_MSK_CS"
    GROUP.LONG 0x0634++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_MSK_PS,CFG_FFT_DINT_MSK_PS"
    GROUP.LONG 0x0638++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_COE_FH,CFG_FFT_DINT_COE_FH"
    GROUP.LONG 0x063C++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_COE_CS,CFG_FFT_DINT_COE_CS"
    GROUP.LONG 0x0640++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_COE_FC,CFG_FFT_DINT_COE_FC"
    GROUP.LONG 0x0644++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_COE_PS_0,CFG_FFT_DINT_COE_PS_0"
    GROUP.LONG 0x0648++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_COE_PS_1,CFG_FFT_DINT_COE_PS_1"
    GROUP.LONG 0x064C++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_COE_PS_2,CFG_FFT_DINT_COE_PS_2"
    GROUP.LONG 0x0650++0x03
        LINE.LONG 0x00 "CFG_FFT_DINT_COE_PS_3,CFG_FFT_DINT_COE_PS_3"
    GROUP.LONG 0x0654++0x03
        LINE.LONG 0x00 "CFG_FFT_NO_WIN,CFG_FFT_NO_WIN"
    GROUP.LONG 0x0658++0x03
        LINE.LONG 0x00 "CFG_FFT_NVE_MODE,CFG_FFT_NVE_MODE"
    GROUP.LONG 0x065C++0x03
        LINE.LONG 0x00 "CFG_FFT_NVE_SCL_0,CFG_FFT_NVE_SCL_0"
    GROUP.LONG 0x0660++0x03
        LINE.LONG 0x00 "CFG_FFT_NVE_SCL_1,CFG_FFT_NVE_SCL_1"
    GROUP.LONG 0x0664++0x03
        LINE.LONG 0x00 "CFG_FFT_NVE_SFT,CFG_FFT_NVE_SFT"
    GROUP.LONG 0x0668++0x03
        LINE.LONG 0x00 "CFG_FFT_NVE_CH_MSK,CFG_FFT_NVE_CH_MSK"
    GROUP.LONG 0x066C++0x03
        LINE.LONG 0x00 "CFG_FFT_NVE_DFT_VALUE,CFG_FFT_NVE_DFT_VALUE"
    GROUP.LONG 0x0670++0x03
        LINE.LONG 0x00 "CFG_FFT_ZER_DPL_ENB,CFG_FFT_ZER_DPL_ENB"
    GROUP.LONG 0x0674++0x03
        LINE.LONG 0x00 "FDB_FFT_DINT_DAT_FH,FDB_FFT_DINT_DAT_FH"
    GROUP.LONG 0x0678++0x03
        LINE.LONG 0x00 "FDB_FFT_DINT_DAT_CS,FDB_FFT_DINT_DAT_CS"
    GROUP.LONG 0x067C++0x03
        LINE.LONG 0x00 "FDB_FFT_DINT_DAT_PS,FDB_FFT_DINT_DAT_PS"
    GROUP.LONG 0x0800++0x03
        LINE.LONG 0x00 "CFG_CFR_SIZE_OBJ,Max obj size register, 0base"
    GROUP.LONG 0x0804++0x03
        LINE.LONG 0x00 "CFG_CFR_BACK_RNG,bc range boundary"
    GROUP.LONG 0x0808++0x03
        LINE.LONG 0x00 "CFG_CFR_TYPE_CMB,CFG_CFR_TYPE_CMB"
    GROUP.LONG 0x080C++0x03
        LINE.LONG 0x00 "CFG_CFR_MIMO_NUM,CFG_CFR_MIMO_NUM"
    GROUP.LONG 0x0810++0x03
        LINE.LONG 0x00 "CFG_CFR_MIMO_ADR,CFG_CFR_MIMO_ADR"
    GROUP.LONG 0x0814++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_VEL_00,Region dependent boundary value, Vel0"
    GROUP.LONG 0x0818++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_VEL_01,Region dependent boundary value, Vel1"
    GROUP.LONG 0x081C++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_VEL_10,Region dependent boundary value, Vel2"
    GROUP.LONG 0x0820++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_VEL_11,Region dependent boundary value, Vel3"
    GROUP.LONG 0x0824++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_VEL_20,Region dependent boundary value, Vel4"
    GROUP.LONG 0x0828++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_VEL_21,Region dependent boundary value, Vel5"
    GROUP.LONG 0x082C++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_VEL_30,Region dependent boundary value, Vel6"
    GROUP.LONG 0x0830++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_VEL_31,Region dependent boundary value, Vel7"
    GROUP.LONG 0x0834++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_RNG_00,Region dependent boundary value, Ran0"
    GROUP.LONG 0x0838++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_RNG_01,Region dependent boundary value, Ran1"
    GROUP.LONG 0x083C++0x03
        LINE.LONG 0x00 "CFG_CFR_PRT_RNG_02,Region dependent boundary value, Ran2"
    GROUP.LONG 0x0840++0x03
        LINE.LONG 0x00 "CFG_CFR_TYP_AL,8 Regions CFAR algorithm scheme"
    GROUP.LONG 0x0844++0x03
        LINE.LONG 0x00 "CFG_CFR_TYP_DS,8 Regions downsampling scheme "
    GROUP.LONG 0x0848++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_0_0,Parameter 0_0 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x084C++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_0_1,Parameter 0_1 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0850++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_1_0,Parameter 1_0 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0854++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_1_1,Parameter 1_1 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0858++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_1_2,Parameter 1_2 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x085C++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_2_0,Parameter 2_0 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0860++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_2_1,Parameter 2_1 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0864++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_2_2,Parameter 2_2 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0868++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_3_0,Parameter 3_0 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x086C++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_3_1,Parameter 3_1 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0870++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_3_2,Parameter 3_2 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0874++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_3_3,Parameter 3_3 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0878++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_4_0,Parameter 4_0 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x087C++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_4_1,Parameter 4_1 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0880++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_5_0,Parameter 5_0 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0884++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_5_1,Parameter 5_1 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0888++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_6_0,Parameter 6_0 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x088C++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_6_1,Parameter 6_1 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0890++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_6_2,Parameter 6_2 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0894++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_6_3,Parameter 6_3 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x0898++0x03
        LINE.LONG 0x00 "CFG_CFR_PRM_7,Parameter 7_0 register, value shared in different CFAR algorithm"
    GROUP.LONG 0x089C++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_00,CFAR window mask register0"
    GROUP.LONG 0x08A0++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_01,CFAR window mask register1"
    GROUP.LONG 0x08A4++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_02,CFAR window mask register2"
    GROUP.LONG 0x08A8++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_03,CFAR window mask register3"
    GROUP.LONG 0x08AC++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_04,CFAR window mask register4"
    GROUP.LONG 0x08B0++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_05,CFAR window mask register5"
    GROUP.LONG 0x08B4++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_06,CFAR window mask register6"
    GROUP.LONG 0x08B8++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_07,CFAR window mask register7"
    GROUP.LONG 0x08BC++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_08,CFAR window mask register8"
    GROUP.LONG 0x08C0++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_09,CFAR window mask register9"
    GROUP.LONG 0x08C4++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_10,CFAR window mask register10"
    GROUP.LONG 0x08C8++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_11,CFAR window mask register11"
    GROUP.LONG 0x08CC++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_12,CFAR window mask register12"
    GROUP.LONG 0x08D0++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_13,CFAR window mask register13"
    GROUP.LONG 0x08D4++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_14,CFAR window mask register14"
    GROUP.LONG 0x08D8++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_15,CFAR window mask register15"
    GROUP.LONG 0x08DC++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_16,CFAR window mask register16"
    GROUP.LONG 0x08E0++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_17,CFAR window mask register17"
    GROUP.LONG 0x08E4++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_18,CFAR window mask register18"
    GROUP.LONG 0x08E8++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_19,CFAR window mask register19"
    GROUP.LONG 0x08EC++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_20,CFAR window mask register20"
    GROUP.LONG 0x08F0++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_21,CFAR window mask register21"
    GROUP.LONG 0x08F4++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_22,CFAR window mask register22"
    GROUP.LONG 0x08F8++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_23,CFAR window mask register23"
    GROUP.LONG 0x08FC++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_24,CFAR window mask register24"
    GROUP.LONG 0x0900++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_25,CFAR window mask register25"
    GROUP.LONG 0x0904++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_26,CFAR window mask register26"
    GROUP.LONG 0x0908++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_27,CFAR window mask register27"
    GROUP.LONG 0x090C++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_28,CFAR window mask register28"
    GROUP.LONG 0x0910++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_29,CFAR window mask register29"
    GROUP.LONG 0x0914++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_30,CFAR window mask register30"
    GROUP.LONG 0x0918++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_DS_31,CFAR window mask register31"
    GROUP.LONG 0x091C++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_PK_00,CFAR peak mask register0"
    GROUP.LONG 0x0920++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_PK_01,CFAR peak mask register1"
    GROUP.LONG 0x0924++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_PK_02,CFAR peak mask register2"
    GROUP.LONG 0x0928++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_PK_03,CFAR peak mask register3"
    GROUP.LONG 0x092C++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_PK_04,CFAR peak mask register4"
    GROUP.LONG 0x0930++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_PK_05,CFAR peak mask register5"
    GROUP.LONG 0x0934++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_PK_06,CFAR peak mask register6"
    GROUP.LONG 0x0938++0x03
        LINE.LONG 0x00 "CFG_CFR_MSK_PK_07,CFAR peak mask register7"
    GROUP.LONG 0x093C++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_ENB,8 region pk function enable"
    GROUP.LONG 0x0940++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_THR_0,region0 pk threshold"
    GROUP.LONG 0x0944++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_THR_1,region1 pk threshold"
    GROUP.LONG 0x0948++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_THR_2,region2 pk threshold"
    GROUP.LONG 0x094C++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_THR_3,region3 pk threshold"
    GROUP.LONG 0x0950++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_THR_4,region4 pk threshold"
    GROUP.LONG 0x0954++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_THR_5,region5 pk threshold"
    GROUP.LONG 0x0958++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_THR_6,region6 pk threshold"
    GROUP.LONG 0x095C++0x03
        LINE.LONG 0x00 "CFG_CFR_PK_THR_7,region7 pk threshold"
    GROUP.LONG 0x0960++0x03
        LINE.LONG 0x00 "CFG_CFR_CS_ENA,Cross window enable"
    GROUP.LONG 0x0964++0x03
        LINE.LONG 0x00 "CFG_CFR_CS_SKP_VEL,velocity level skip size register"
    GROUP.LONG 0x0968++0x03
        LINE.LONG 0x00 "CFG_CFR_CS_SKP_RNG,range level skip size register"
    GROUP.LONG 0x096C++0x03
        LINE.LONG 0x00 "CFG_CFR_CS_SIZ_VEL,velocity level cross size register"
    GROUP.LONG 0x0970++0x03
        LINE.LONG 0x00 "CFG_CFR_CS_SIZ_RNG,range level cross size register"
    GROUP.LONG 0x0974++0x03
        LINE.LONG 0x00 "CFG_CFR_TYP_NOI,8 region noise level output select register"
    GROUP.LONG 0x0978++0x03
        LINE.LONG 0x00 "FDB_CFR_NUMB_OBJ,CFAR detect target number"
    GROUP.LONG 0x0A00++0x03
        LINE.LONG 0x00 "CFG_DOA_DAMB_FRDTRA,CFG_DOA_DAMB_FRDTRA"
    GROUP.LONG 0x0A04++0x03
        LINE.LONG 0x00 "CFG_DOA_DAMB_IDX_BGN,CFG_DOA_DAMB_IDX_BGN"
    GROUP.LONG 0x0A08++0x03
        LINE.LONG 0x00 "CFG_DOA_DAMB_IDX_LEN,CFG_DOA_DAMB_IDX_LEN"
    GROUP.LONG 0x0A0C++0x03
        LINE.LONG 0x00 "CFG_DOA_DAMB_TYP,CFG_DOA_DAMB_TYP"
    GROUP.LONG 0x0A10++0x03
        LINE.LONG 0x00 "CFG_DOA_DAMB_DEFQ,CFG_DOA_DAMB_DEFQ"
    GROUP.LONG 0x0A14++0x03
        LINE.LONG 0x00 "CFG_DOA_DAMB_FDTR,CFG_DOA_DAMB_FDTR"
    GROUP.LONG 0x0A18++0x03
        LINE.LONG 0x00 "CFG_DOA_DAMB_VELCOM,CFG_DOA_DAMB_VELCOM"
    GROUP.LONG 0x0A1C++0x03
        LINE.LONG 0x00 "CFG_DOA_DBPM_ENA,CFG_DOA_DBPM_ENA"
    GROUP.LONG 0x0A20++0x03
        LINE.LONG 0x00 "CFG_DOA_DBPM_ADR,CFG_DOA_DBPM_ADR"
    GROUP.LONG 0x0A24++0x03
        LINE.LONG 0x00 "CFG_DOA_MODE_RUN,CFG_DOA_MODE_RUN"
    GROUP.LONG 0x0A28++0x03
        LINE.LONG 0x00 "CFG_DOA_NUMB_OBJ,CFG_DOA_NUMB_OBJ"
    GROUP.LONG 0x0A2C++0x03
        LINE.LONG 0x00 "CFG_DOA_MODE_GRP,CFG_DOA_MODE_GRP"
    GROUP.LONG 0x0A30++0x03
        LINE.LONG 0x00 "CFG_DOA_NUMB_GRP,CFG_DOA_NUMB_GRP"
    GROUP.LONG 0x0A34++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_TYP_SCH,CFG_DOA_GRP0_TYP_SCH"
    GROUP.LONG 0x0A38++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_MOD_SCH,CFG_DOA_GRP0_MOD_SCH"
    GROUP.LONG 0x0A3C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_NUM_SCH,CFG_DOA_GRP0_NUM_SCH"
    GROUP.LONG 0x0A40++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_ADR_COE,CFG_DOA_GRP0_ADR_COE"
    GROUP.LONG 0x0A44++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_ONE_ANG,CFG_DOA_GRP0_SIZ_ONE_ANG"
    GROUP.LONG 0x0A48++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_RNG_PKS_CRS,CFG_DOA_GRP0_SIZ_RNG_PKS_CRS"
    GROUP.LONG 0x0A4C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_STP_PKS_CRS,CFG_DOA_GRP0_SIZ_STP_PKS_CRS"
    GROUP.LONG 0x0A50++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_RNG_PKS_RFD,CFG_DOA_GRP0_SIZ_RNG_PKS_RFD"
    GROUP.LONG 0x0A54++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_CMB,CFG_DOA_GRP0_SIZ_CMB"
    GROUP.LONG 0x0A58++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_DAT_IDX_0,CFG_DOA_GRP0_DAT_IDX_0"
    GROUP.LONG 0x0A5C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_DAT_IDX_1,CFG_DOA_GRP0_DAT_IDX_1"
    GROUP.LONG 0x0A60++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_DAT_IDX_2,CFG_DOA_GRP0_DAT_IDX_2"
    GROUP.LONG 0x0A64++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_DAT_IDX_3,CFG_DOA_GRP0_DAT_IDX_3"
    GROUP.LONG 0x0A68++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_DAT_IDX_4,CFG_DOA_GRP0_DAT_IDX_4"
    GROUP.LONG 0x0A6C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_DAT_IDX_5,CFG_DOA_GRP0_DAT_IDX_5"
    GROUP.LONG 0x0A70++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_DAT_IDX_6,CFG_DOA_GRP0_DAT_IDX_6"
    GROUP.LONG 0x0A74++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_DAT_IDX_7,CFG_DOA_GRP0_DAT_IDX_7"
    GROUP.LONG 0x0A78++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_WIN,CFG_DOA_GRP0_SIZ_WIN"
    GROUP.LONG 0x0A7C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_THR_SNR_0,CFG_DOA_GRP0_THR_SNR_0"
    GROUP.LONG 0x0A80++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_THR_SNR_1,CFG_DOA_GRP0_THR_SNR_1"
    GROUP.LONG 0x0A84++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SCL_POW,CFG_DOA_GRP0_SCL_POW"
    GROUP.LONG 0x0A88++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SCL_NOI_0,CFG_DOA_GRP0_SCL_NOI_0"
    GROUP.LONG 0x0A8C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SCL_NOI_1,CFG_DOA_GRP0_SCL_NOI_1"
    GROUP.LONG 0x0A90++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SCL_NOI_2,CFG_DOA_GRP0_SCL_NOI_2"
    GROUP.LONG 0x0A94++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_TST_POW,CFG_DOA_GRP0_TST_POW"
    GROUP.LONG 0x0A98++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_RNG_AML,CFG_DOA_GRP0_SIZ_RNG_AML"
    GROUP.LONG 0x0A9C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_STP_AML_CRS,CFG_DOA_GRP0_SIZ_STP_AML_CRS"
    GROUP.LONG 0x0AA0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_STP_AML_RFD,CFG_DOA_GRP0_SIZ_STP_AML_RFD"
    GROUP.LONG 0x0AA4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SCL_REM_0,CFG_DOA_GRP0_SCL_REM_0"
    GROUP.LONG 0x0AA8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SCL_REM_1,CFG_DOA_GRP0_SCL_REM_1"
    GROUP.LONG 0x0AAC++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SCL_REM_2,CFG_DOA_GRP0_SCL_REM_2"
    GROUP.LONG 0x0AB0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_ENA_NEI,CFG_DOA_GRP0_ENA_NEI"
    GROUP.LONG 0x0AB4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_SIZ_SUB,CFG_DOA_GRP0_SIZ_SUB"
    GROUP.LONG 0x0AB8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP0_TYP_SMO,CFG_DOA_GRP0_TYP_SMO"
    GROUP.LONG 0x0ABC++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_TYP_SCH,CFG_DOA_GRP1_TYP_SCH"
    GROUP.LONG 0x0AC0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_MOD_SCH,CFG_DOA_GRP1_MOD_SCH"
    GROUP.LONG 0x0AC4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_NUM_SCH,CFG_DOA_GRP1_NUM_SCH"
    GROUP.LONG 0x0AC8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_ADR_COE,CFG_DOA_GRP1_ADR_COE"
    GROUP.LONG 0x0ACC++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_ONE_ANG,CFG_DOA_GRP1_SIZ_ONE_ANG"
    GROUP.LONG 0x0AD0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_RNG_PKS_CRS,CFG_DOA_GRP1_SIZ_RNG_PKS_CRS"
    GROUP.LONG 0x0AD4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_STP_PKS_CRS,CFG_DOA_GRP1_SIZ_STP_PKS_CRS"
    GROUP.LONG 0x0AD8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_RNG_PKS_RFD,CFG_DOA_GRP1_SIZ_RNG_PKS_RFD"
    GROUP.LONG 0x0ADC++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_CMB,CFG_DOA_GRP1_SIZ_CMB"
    GROUP.LONG 0x0AE0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_DAT_IDX_0,CFG_DOA_GRP1_DAT_IDX_0"
    GROUP.LONG 0x0AE4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_DAT_IDX_1,CFG_DOA_GRP1_DAT_IDX_1"
    GROUP.LONG 0x0AE8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_DAT_IDX_2,CFG_DOA_GRP1_DAT_IDX_2"
    GROUP.LONG 0x0AEC++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_DAT_IDX_3,CFG_DOA_GRP1_DAT_IDX_3"
    GROUP.LONG 0x0AF0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_DAT_IDX_4,CFG_DOA_GRP1_DAT_IDX_4"
    GROUP.LONG 0x0AF4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_DAT_IDX_5,CFG_DOA_GRP1_DAT_IDX_5"
    GROUP.LONG 0x0AF8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_DAT_IDX_6,CFG_DOA_GRP1_DAT_IDX_6"
    GROUP.LONG 0x0AFC++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_DAT_IDX_7,CFG_DOA_GRP1_DAT_IDX_7"
    GROUP.LONG 0x0B00++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_WIN,CFG_DOA_GRP1_SIZ_WIN"
    GROUP.LONG 0x0B04++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_THR_SNR_0,CFG_DOA_GRP1_THR_SNR_0"
    GROUP.LONG 0x0B08++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_THR_SNR_1,CFG_DOA_GRP1_THR_SNR_1"
    GROUP.LONG 0x0B0C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SCL_POW,CFG_DOA_GRP1_SCL_POW"
    GROUP.LONG 0x0B10++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SCL_NOI_0,CFG_DOA_GRP1_SCL_NOI_0"
    GROUP.LONG 0x0B14++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SCL_NOI_1,CFG_DOA_GRP1_SCL_NOI_1"
    GROUP.LONG 0x0B18++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SCL_NOI_2,CFG_DOA_GRP1_SCL_NOI_2"
    GROUP.LONG 0x0B1C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_TST_POW,CFG_DOA_GRP1_TST_POW"
    GROUP.LONG 0x0B20++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_RNG_AML,CFG_DOA_GRP1_SIZ_RNG_AML"
    GROUP.LONG 0x0B24++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_STP_AML_CRS,CFG_DOA_GRP1_SIZ_STP_AML_CRS"
    GROUP.LONG 0x0B28++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_STP_AML_RFD,CFG_DOA_GRP1_SIZ_STP_AML_RFD"
    GROUP.LONG 0x0B2C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SCL_REM_0,CFG_DOA_GRP1_SCL_REM_0"
    GROUP.LONG 0x0B30++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SCL_REM_1,CFG_DOA_GRP1_SCL_REM_1"
    GROUP.LONG 0x0B34++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SCL_REM_2,CFG_DOA_GRP1_SCL_REM_2"
    GROUP.LONG 0x0B38++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_ENA_NEI,CFG_DOA_GRP1_ENA_NEI"
    GROUP.LONG 0x0B3C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_SIZ_SUB,CFG_DOA_GRP1_SIZ_SUB"
    GROUP.LONG 0x0B40++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP1_TYP_SMO,CFG_DOA_GRP1_TYP_SMO"
    GROUP.LONG 0x0B44++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_TYP_SCH,CFG_DOA_GRP2_TYP_SCH"
    GROUP.LONG 0x0B48++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_MOD_SCH,CFG_DOA_GRP2_MOD_SCH"
    GROUP.LONG 0x0B4C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_NUM_SCH,CFG_DOA_GRP2_NUM_SCH"
    GROUP.LONG 0x0B50++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_ADR_COE,CFG_DOA_GRP2_ADR_COE"
    GROUP.LONG 0x0B54++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_ONE_ANG,CFG_DOA_GRP2_SIZ_ONE_ANG"
    GROUP.LONG 0x0B58++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_RNG_PKS_CRS,CFG_DOA_GRP2_SIZ_RNG_PKS_CRS"
    GROUP.LONG 0x0B5C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_STP_PKS_CRS,CFG_DOA_GRP2_SIZ_STP_PKS_CRS"
    GROUP.LONG 0x0B60++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_RNG_PKS_RFD,CFG_DOA_GRP2_SIZ_RNG_PKS_RFD"
    GROUP.LONG 0x0B64++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_CMB,CFG_DOA_GRP2_SIZ_CMB"
    GROUP.LONG 0x0B68++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_DAT_IDX_0,CFG_DOA_GRP2_DAT_IDX_0"
    GROUP.LONG 0x0B6C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_DAT_IDX_1,CFG_DOA_GRP2_DAT_IDX_1"
    GROUP.LONG 0x0B70++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_DAT_IDX_2,CFG_DOA_GRP2_DAT_IDX_2"
    GROUP.LONG 0x0B74++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_DAT_IDX_3,CFG_DOA_GRP2_DAT_IDX_3"
    GROUP.LONG 0x0B78++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_DAT_IDX_4,CFG_DOA_GRP2_DAT_IDX_4"
    GROUP.LONG 0x0B7C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_DAT_IDX_5,CFG_DOA_GRP2_DAT_IDX_5"
    GROUP.LONG 0x0B80++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_DAT_IDX_6,CFG_DOA_GRP2_DAT_IDX_6"
    GROUP.LONG 0x0B84++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_DAT_IDX_7,CFG_DOA_GRP2_DAT_IDX_7"
    GROUP.LONG 0x0B88++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_WIN,CFG_DOA_GRP2_SIZ_WIN"
    GROUP.LONG 0x0B8C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_THR_SNR_0,CFG_DOA_GRP2_THR_SNR_0"
    GROUP.LONG 0x0B90++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_THR_SNR_1,CFG_DOA_GRP2_THR_SNR_1"
    GROUP.LONG 0x0B94++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SCL_POW,CFG_DOA_GRP2_SCL_POW"
    GROUP.LONG 0x0B98++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SCL_NOI_0,CFG_DOA_GRP2_SCL_NOI_0"
    GROUP.LONG 0x0B9C++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SCL_NOI_1,CFG_DOA_GRP2_SCL_NOI_1"
    GROUP.LONG 0x0BA0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SCL_NOI_2,CFG_DOA_GRP2_SCL_NOI_2"
    GROUP.LONG 0x0BA4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_TST_POW,CFG_DOA_GRP2_TST_POW"
    GROUP.LONG 0x0BA8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_RNG_AML,CFG_DOA_GRP2_SIZ_RNG_AML"
    GROUP.LONG 0x0BAC++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_STP_AML_CRS,CFG_DOA_GRP2_SIZ_STP_AML_CRS"
    GROUP.LONG 0x0BB0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_STP_AML_RFD,CFG_DOA_GRP2_SIZ_STP_AML_RFD"
    GROUP.LONG 0x0BB4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SCL_REM_0,CFG_DOA_GRP2_SCL_REM_0"
    GROUP.LONG 0x0BB8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SCL_REM_1,CFG_DOA_GRP2_SCL_REM_1"
    GROUP.LONG 0x0BBC++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SCL_REM_2,CFG_DOA_GRP2_SCL_REM_2"
    GROUP.LONG 0x0BC0++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_ENA_NEI,CFG_DOA_GRP2_ENA_NEI"
    GROUP.LONG 0x0BC4++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_SIZ_SUB,CFG_DOA_GRP2_SIZ_SUB"
    GROUP.LONG 0x0BC8++0x03
        LINE.LONG 0x00 "CFG_DOA_GRP2_TYP_SMO,CFG_DOA_GRP2_TYP_SMO"
    GROUP.LONG 0x0BCC++0x03
        LINE.LONG 0x00 "CFG_DOA_C2D1_ADR_COE,CFG_DOA_C2D1_ADR_COE"
    GROUP.LONG 0x0BD0++0x03
        LINE.LONG 0x00 "CFG_DOA_C2D1_SIZ_CMB,CFG_DOA_C2D1_SIZ_CMB"
    GROUP.LONG 0x0BD4++0x03
        LINE.LONG 0x00 "CFG_DOA_C2D2_ADR_COE,CFG_DOA_C2D2_ADR_COE"
    GROUP.LONG 0x0BD8++0x03
        LINE.LONG 0x00 "CFG_DOA_C2D2_SIZ_CMB,CFG_DOA_C2D2_SIZ_CMB"
    GROUP.LONG 0x0BDC++0x03
        LINE.LONG 0x00 "CFG_DOA_C2D3_ADR_COE,CFG_DOA_C2D3_ADR_COE"
    GROUP.LONG 0x0BE0++0x03
        LINE.LONG 0x00 "CFG_DOA_C2D3_SIZ_CMB,CFG_DOA_C2D3_SIZ_CMB"
    GROUP.LONG 0x0C00++0x03
        LINE.LONG 0x00 "CFG_DBG_BUF_TAR,CFG_DBG_BUF_TAR"
    GROUP.LONG 0x0C04++0x03
        LINE.LONG 0x00 "CFG_DBG_MAP_RLT,CFG_DBG_MAP_RLT"
    GROUP.LONG 0x0C08++0x03
        LINE.LONG 0x00 "CTL_DBG_RFRSH_START,CTL_DBG_RFRSH_START"
    GROUP.LONG 0x0C0C++0x03
        LINE.LONG 0x00 "CTL_DBG_RFRSH_CLR,CTL_DBG_RFRSH_CLR"
    GROUP.LONG 0x0C10++0x03
        LINE.LONG 0x00 "FDB_DBG_RFRSH_STATUS,FDB_DBG_RFRSH_STATUS"
    GROUP.LONG 0x0E00++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_SV_STP,step size of DML coarse seach in group 0"
    GROUP.LONG 0x0E04++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_SV_START,start position of DML coefficients in group 0"
    GROUP.LONG 0x0E08++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_SV_END,stop position of DML coefficients in group 0"
    GROUP.LONG 0x0E0C++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_DC_COE_0,decision function coefficient 0 in group 0"
    GROUP.LONG 0x0E10++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_DC_COE_1,decision function coefficient 1 in group 0"
    GROUP.LONG 0x0E14++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_DC_COE_2,decision function coefficient 2 in group 0"
    GROUP.LONG 0x0E18++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_DC_COE_3,decision function coefficient 3 in group 0"
    GROUP.LONG 0x0E1C++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_DC_COE_4,decision function coefficient 4 in group 0"
    GROUP.LONG 0x0E20++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_EXTRA_EN,enable bit for DML extra seach  in group 0"
    GROUP.LONG 0x0E24++0x03
        LINE.LONG 0x00 "CFG_DML_GRP0_DC_COE_2_EN,enable bit for  2nd part in decision function  in group 0"
    GROUP.LONG 0x0E28++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_SV_STP,step size of DML coarse seach in group 1"
    GROUP.LONG 0x0E2C++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_SV_START,start position of DML coefficients in group 1"
    GROUP.LONG 0x0E30++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_SV_END,stop position of DML coefficients in group 1"
    GROUP.LONG 0x0E34++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_DC_COE_0,decision function coefficient 0 in group 1"
    GROUP.LONG 0x0E38++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_DC_COE_1,decision function coefficient 1 in group 1"
    GROUP.LONG 0x0E3C++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_DC_COE_2,decision function coefficient 2 in group 1"
    GROUP.LONG 0x0E40++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_DC_COE_3,decision function coefficient 3 in group 1"
    GROUP.LONG 0x0E44++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_DC_COE_4,decision function coefficient 4 in group 1"
    GROUP.LONG 0x0E48++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_EXTRA_EN,enable bit for DML extra seach in group 1"
    GROUP.LONG 0x0E4C++0x03
        LINE.LONG 0x00 "CFG_DML_GRP1_DC_COE_2_EN,enable bit for  2nd part in decision function in  group 1"
    GROUP.LONG 0x0E50++0x03
        LINE.LONG 0x00 "CFG_DML_MEM_BASE_ADR,address offset for group 1 in DML Memory(D,K coefficient)"
TREE.END

AUTOINDENT.ON LEFT TREE
TREE "DMA MODULE"
    
TREE "Channel 0"
	BASE ad:0xC20000
	GROUP.QUAD 0x0++0x8
        LINE.QUAD 0x00 "SAR,Source Address for Channel 0"
            BITFLD.QUAD 0x00 0.--31. "SAR    ,SAR"
    GROUP.QUAD 0x8++0x8
        LINE.QUAD 0x00 "DAR,Destination Address Register for Channel 0"
            BITFLD.QUAD 0x00 0.--31. "DAR    ,DAR"
    GROUP.QUAD 0x10++0x8
        LINE.QUAD 0x00 "LLP,Linked List Pointer Register for Channel 0"
            BITFLD.QUAD 0x00 2.--31. "LOC    ,LOC"
            BITFLD.QUAD 0x00 0.--1. "LMS    ,LMS" "0,1,2,3"
	GROUP.QUAD 0x18++0x8
        LINE.QUAD 0x00 "CTL,Control Register for Channel 0"
            BITFLD.QUAD 0x00 44. "DONE    ,DONE" "0,1"
            BITFLD.QUAD 0x00 37.--43. "Rsvd_2_CTL    ,Rsvd_2_CTL"
            BITFLD.QUAD 0x00 32.--36. "BLOCK_TS    ,BLOCK_TS"
            BITFLD.QUAD 0x00 29.--31. "Rsvd_1_CTL    ,Rsvd_1_CTL"
            NEWLINE
            BITFLD.QUAD 0x00 28. "LLP_SRC_EN    ,LLP_SRC_EN" "0,1"
            BITFLD.QUAD 0x00 27. "LLP_DST_EN    ,LLP_DST_EN" "0,1"
            BITFLD.QUAD 0x00 25.--26. "SMS    ,SMS" "0,1,2,3"
            BITFLD.QUAD 0x00 23.--24. "DMS    ,DMS" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 20.--22. "TT_FC    ,TT_FC"
            BITFLD.QUAD 0x00 19. "Rsvd_CTL    ,Rsvd_CTL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_SCATTER_EN    ,DST_SCATTER_EN" "0,1"
            BITFLD.QUAD 0x00 17. "SRC_GATHER_EN    ,SRC_GATHER_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 14.--16. "SRC_MSIZE    ,SRC_MSIZE"
            BITFLD.QUAD 0x00 11.--13. "DEST_MSIZE    ,DEST_MSIZE"
            BITFLD.QUAD 0x00 9.--10. "SINC    ,SINC" "0,1,2,3"
            BITFLD.QUAD 0x00 7.--8. "DINC    ,DINC" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 4.--6. "SRC_TR_WIDTH    ,SRC_TR_WIDTH"
            BITFLD.QUAD 0x00 1.--3. "DST_TR_WIDTH    ,DST_TR_WIDTH"
            BITFLD.QUAD 0x00 0. "INT_EN    ,INT_EN" "0,1"
    GROUP.QUAD 0x20++0x8
        LINE.QUAD 0x00 "SSTAT,Source Status Register for Channel 0"
            BITFLD.QUAD 0x00 0.--31. "SSTAT    ,SSTAT"
    GROUP.QUAD 0x28++0x8
        LINE.QUAD 0x00 "DSTAT,Destination Status Register for Channel 0"
            BITFLD.QUAD 0x00 0.--31. "DSTAT    ,DSTAT"
    GROUP.QUAD 0x30++0x8
        LINE.QUAD 0x00 "SSTATR,Source Status Address Register for Channel 0"
            BITFLD.QUAD 0x00 0.--31. "SSTATAR    ,SSTATAR"
    GROUP.QUAD 0x38++0x8
        LINE.QUAD 0x00 "DSTATAR,Destination Status Address Register for Channel 0"
            BITFLD.QUAD 0x00 0.--31. "DSTATAR    ,DSTATAR"
	GROUP.QUAD 0x40++0x8
        LINE.QUAD 0x00 "CFG,Configuration Register for Channel 0"
            BITFLD.QUAD 0x00 43.--46. "DEST_PER    ,DEST_PER"
            BITFLD.QUAD 0x00 39.--42. "SRC_PER    ,SRC_PER"
            BITFLD.QUAD 0x00 38. "SS_UPD_EN    ,SS_UPD_EN" "0,1"
            BITFLD.QUAD 0x00 37. "DS_UPD_EN    ,DS_UPD_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 34.--36. "PROTCTL    ,PROTCTL"
            BITFLD.QUAD 0x00 33. "FIFO_MODE    ,FIFO_MODE" "0,1"
            BITFLD.QUAD 0x00 32. "FCMODE    ,FCMODE" "0,1"
            BITFLD.QUAD 0x00 31. "RELOAD_DST    ,RELOAD_DST" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 30. "RELOAD_SRC    ,RELOAD_SRC" "0,1"
            BITFLD.QUAD 0x00 20.--29. "Rsvd2_CFG    ,Rsvd2_CFG"
            BITFLD.QUAD 0x00 19. "SRC_HS_POL    ,SRC_HS_POL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_HS_POL    ,DST_HS_POL" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 12.--17. "Rsvd1_CFG    ,Rsvd1_CFG"
            BITFLD.QUAD 0x00 11. "HS_SEL_SRC    ,HS_SEL_SRC" "0,1"
            BITFLD.QUAD 0x00 10. "HS_SEL_DST    ,HS_SEL_DST" "0,1"
            BITFLD.QUAD 0x00 9. "FIFO_EMPTY    ,FIFO_EMPTY" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 8. "CH_SUSP    ,CH_SUSP" "0,1"
            BITFLD.QUAD 0x00 5.--7. "CH_PRIOR    ,CH_PRIOR"
            BITFLD.QUAD 0x00 0.--4. "Rsvd_CFG    ,Rsvd_CFG"
    GROUP.QUAD 0x48++0x8
        LINE.QUAD 0x00 "SGR,Source Gather Register for Channel 0"
            BITFLD.QUAD 0x00 20.--50. "SGC    ,SGC"
            BITFLD.QUAD 0x00 0.--19. "SGI    ,SGI"
    GROUP.QUAD 0x50++0x8
        LINE.QUAD 0x00 "DSR,Destination Scatter Register for Channel 0"
            BITFLD.QUAD 0x00 20.--50. "DSC    ,DSC"
            BITFLD.QUAD 0x00 0.--19. "DSI    ,DSI"
TREE.END	

TREE "Channel 1"
	BASE ad:0xC20058
	GROUP.QUAD 0x0++0x8
        LINE.QUAD 0x00 "SAR,Source Address for Channel 1"
            BITFLD.QUAD 0x00 0.--31. "SAR    ,SAR"
    GROUP.QUAD 0x8++0x8
        LINE.QUAD 0x00 "DAR,Destination Address Register for Channel 1"
            BITFLD.QUAD 0x00 0.--31. "DAR    ,DAR"
    GROUP.QUAD 0x10++0x8
        LINE.QUAD 0x00 "LLP,Linked List Pointer Register for Channel 1"
            BITFLD.QUAD 0x00 2.--31. "LOC    ,LOC"
            BITFLD.QUAD 0x00 0.--1. "LMS    ,LMS" "0,1,2,3"
	GROUP.QUAD 0x18++0x8
        LINE.QUAD 0x00 "CTL,Control Register for Channel 1"
            BITFLD.QUAD 0x00 44. "DONE    ,DONE" "0,1"
            BITFLD.QUAD 0x00 37.--43. "Rsvd_2_CTL    ,Rsvd_2_CTL"
            BITFLD.QUAD 0x00 32.--36. "BLOCK_TS    ,BLOCK_TS"
            BITFLD.QUAD 0x00 29.--31. "Rsvd_1_CTL    ,Rsvd_1_CTL"
            NEWLINE
            BITFLD.QUAD 0x00 28. "LLP_SRC_EN    ,LLP_SRC_EN" "0,1"
            BITFLD.QUAD 0x00 27. "LLP_DST_EN    ,LLP_DST_EN" "0,1"
            BITFLD.QUAD 0x00 25.--26. "SMS    ,SMS" "0,1,2,3"
            BITFLD.QUAD 0x00 23.--24. "DMS    ,DMS" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 20.--22. "TT_FC    ,TT_FC"
            BITFLD.QUAD 0x00 19. "Rsvd_CTL    ,Rsvd_CTL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_SCATTER_EN    ,DST_SCATTER_EN" "0,1"
            BITFLD.QUAD 0x00 17. "SRC_GATHER_EN    ,SRC_GATHER_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 14.--16. "SRC_MSIZE    ,SRC_MSIZE"
            BITFLD.QUAD 0x00 11.--13. "DEST_MSIZE    ,DEST_MSIZE"
            BITFLD.QUAD 0x00 9.--10. "SINC    ,SINC" "0,1,2,3"
            BITFLD.QUAD 0x00 7.--8. "DINC    ,DINC" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 4.--6. "SRC_TR_WIDTH    ,SRC_TR_WIDTH"
            BITFLD.QUAD 0x00 1.--3. "DST_TR_WIDTH    ,DST_TR_WIDTH"
            BITFLD.QUAD 0x00 0. "INT_EN    ,INT_EN" "0,1"
    GROUP.QUAD 0x20++0x8
        LINE.QUAD 0x00 "SSTAT,Source Status Register for Channel 1"
            BITFLD.QUAD 0x00 0.--31. "SSTAT    ,SSTAT"
    GROUP.QUAD 0x28++0x8
        LINE.QUAD 0x00 "DSTAT,Destination Status Register for Channel 1"
            BITFLD.QUAD 0x00 0.--31. "DSTAT    ,DSTAT"
    GROUP.QUAD 0x30++0x8
        LINE.QUAD 0x00 "SSTATR,Source Status Address Register for Channel 1"
            BITFLD.QUAD 0x00 0.--31. "SSTATAR    ,SSTATAR"
    GROUP.QUAD 0x38++0x8
        LINE.QUAD 0x00 "DSTATAR,Destination Status Address Register for Channel 1"
            BITFLD.QUAD 0x00 0.--31. "DSTATAR    ,DSTATAR"
	GROUP.QUAD 0x40++0x8
        LINE.QUAD 0x00 "CFG,Configuration Register for Channel 1"
            BITFLD.QUAD 0x00 43.--46. "DEST_PER    ,DEST_PER"
            BITFLD.QUAD 0x00 39.--42. "SRC_PER    ,SRC_PER"
            BITFLD.QUAD 0x00 38. "SS_UPD_EN    ,SS_UPD_EN" "0,1"
            BITFLD.QUAD 0x00 37. "DS_UPD_EN    ,DS_UPD_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 34.--36. "PROTCTL    ,PROTCTL"
            BITFLD.QUAD 0x00 33. "FIFO_MODE    ,FIFO_MODE" "0,1"
            BITFLD.QUAD 0x00 32. "FCMODE    ,FCMODE" "0,1"
            BITFLD.QUAD 0x00 31. "RELOAD_DST    ,RELOAD_DST" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 30. "RELOAD_SRC    ,RELOAD_SRC" "0,1"
            BITFLD.QUAD 0x00 20.--29. "Rsvd2_CFG    ,Rsvd2_CFG"
            BITFLD.QUAD 0x00 19. "SRC_HS_POL    ,SRC_HS_POL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_HS_POL    ,DST_HS_POL" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 12.--17. "Rsvd1_CFG    ,Rsvd1_CFG"
            BITFLD.QUAD 0x00 11. "HS_SEL_SRC    ,HS_SEL_SRC" "0,1"
            BITFLD.QUAD 0x00 10. "HS_SEL_DST    ,HS_SEL_DST" "0,1"
            BITFLD.QUAD 0x00 9. "FIFO_EMPTY    ,FIFO_EMPTY" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 8. "CH_SUSP    ,CH_SUSP" "0,1"
            BITFLD.QUAD 0x00 5.--7. "CH_PRIOR    ,CH_PRIOR"
            BITFLD.QUAD 0x00 0.--4. "Rsvd_CFG    ,Rsvd_CFG"
    GROUP.QUAD 0x48++0x8
        LINE.QUAD 0x00 "SGR,Source Gather Register for Channel 1"
            BITFLD.QUAD 0x00 20.--50. "SGC    ,SGC"
            BITFLD.QUAD 0x00 0.--19. "SGI    ,SGI"
    GROUP.QUAD 0x50++0x8
        LINE.QUAD 0x00 "DSR,Destination Scatter Register for Channel 1"
            BITFLD.QUAD 0x00 20.--50. "DSC    ,DSC"
            BITFLD.QUAD 0x00 0.--19. "DSI    ,DSI"
TREE.END	
    
TREE "Channel 2"
	BASE ad:0xC200B0
	GROUP.QUAD 0x0++0x8
        LINE.QUAD 0x00 "SAR,Source Address for Channel 2"
            BITFLD.QUAD 0x00 0.--31. "SAR    ,SAR"
    GROUP.QUAD 0x8++0x8
        LINE.QUAD 0x00 "DAR,Destination Address Register for Channel 2"
            BITFLD.QUAD 0x00 0.--31. "DAR    ,DAR"
    GROUP.QUAD 0x10++0x8
        LINE.QUAD 0x00 "LLP,Linked List Pointer Register for Channel 2"
            BITFLD.QUAD 0x00 2.--31. "LOC    ,LOC"
            BITFLD.QUAD 0x00 0.--1. "LMS    ,LMS" "0,1,2,3"
	GROUP.QUAD 0x18++0x8
        LINE.QUAD 0x00 "CTL,Control Register for Channel 2"
            BITFLD.QUAD 0x00 44. "DONE    ,DONE" "0,1"
            BITFLD.QUAD 0x00 37.--43. "Rsvd_2_CTL    ,Rsvd_2_CTL"
            BITFLD.QUAD 0x00 32.--36. "BLOCK_TS    ,BLOCK_TS"
            BITFLD.QUAD 0x00 29.--31. "Rsvd_1_CTL    ,Rsvd_1_CTL"
            NEWLINE
            BITFLD.QUAD 0x00 28. "LLP_SRC_EN    ,LLP_SRC_EN" "0,1"
            BITFLD.QUAD 0x00 27. "LLP_DST_EN    ,LLP_DST_EN" "0,1"
            BITFLD.QUAD 0x00 25.--26. "SMS    ,SMS" "0,1,2,3"
            BITFLD.QUAD 0x00 23.--24. "DMS    ,DMS" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 20.--22. "TT_FC    ,TT_FC"
            BITFLD.QUAD 0x00 19. "Rsvd_CTL    ,Rsvd_CTL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_SCATTER_EN    ,DST_SCATTER_EN" "0,1"
            BITFLD.QUAD 0x00 17. "SRC_GATHER_EN    ,SRC_GATHER_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 14.--16. "SRC_MSIZE    ,SRC_MSIZE"
            BITFLD.QUAD 0x00 11.--13. "DEST_MSIZE    ,DEST_MSIZE"
            BITFLD.QUAD 0x00 9.--10. "SINC    ,SINC" "0,1,2,3"
            BITFLD.QUAD 0x00 7.--8. "DINC    ,DINC" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 4.--6. "SRC_TR_WIDTH    ,SRC_TR_WIDTH"
            BITFLD.QUAD 0x00 1.--3. "DST_TR_WIDTH    ,DST_TR_WIDTH"
            BITFLD.QUAD 0x00 0. "INT_EN    ,INT_EN" "0,1"
    GROUP.QUAD 0x20++0x8
        LINE.QUAD 0x00 "SSTAT,Source Status Register for Channel 2"
            BITFLD.QUAD 0x00 0.--31. "SSTAT    ,SSTAT"
    GROUP.QUAD 0x28++0x8
        LINE.QUAD 0x00 "DSTAT,Destination Status Register for Channel 2"
            BITFLD.QUAD 0x00 0.--31. "DSTAT    ,DSTAT"
    GROUP.QUAD 0x30++0x8
        LINE.QUAD 0x00 "SSTATR,Source Status Address Register for Channel 2"
            BITFLD.QUAD 0x00 0.--31. "SSTATAR    ,SSTATAR"
    GROUP.QUAD 0x38++0x8
        LINE.QUAD 0x00 "DSTATAR,Destination Status Address Register for Channel 2"
            BITFLD.QUAD 0x00 0.--31. "DSTATAR    ,DSTATAR"
	GROUP.QUAD 0x40++0x8
        LINE.QUAD 0x00 "CFG,Configuration Register for Channel 2"
            BITFLD.QUAD 0x00 43.--46. "DEST_PER    ,DEST_PER"
            BITFLD.QUAD 0x00 39.--42. "SRC_PER    ,SRC_PER"
            BITFLD.QUAD 0x00 38. "SS_UPD_EN    ,SS_UPD_EN" "0,1"
            BITFLD.QUAD 0x00 37. "DS_UPD_EN    ,DS_UPD_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 34.--36. "PROTCTL    ,PROTCTL"
            BITFLD.QUAD 0x00 33. "FIFO_MODE    ,FIFO_MODE" "0,1"
            BITFLD.QUAD 0x00 32. "FCMODE    ,FCMODE" "0,1"
            BITFLD.QUAD 0x00 31. "RELOAD_DST    ,RELOAD_DST" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 30. "RELOAD_SRC    ,RELOAD_SRC" "0,1"
            BITFLD.QUAD 0x00 20.--29. "Rsvd2_CFG    ,Rsvd2_CFG"
            BITFLD.QUAD 0x00 19. "SRC_HS_POL    ,SRC_HS_POL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_HS_POL    ,DST_HS_POL" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 12.--17. "Rsvd1_CFG    ,Rsvd1_CFG"
            BITFLD.QUAD 0x00 11. "HS_SEL_SRC    ,HS_SEL_SRC" "0,1"
            BITFLD.QUAD 0x00 10. "HS_SEL_DST    ,HS_SEL_DST" "0,1"
            BITFLD.QUAD 0x00 9. "FIFO_EMPTY    ,FIFO_EMPTY" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 8. "CH_SUSP    ,CH_SUSP" "0,1"
            BITFLD.QUAD 0x00 5.--7. "CH_PRIOR    ,CH_PRIOR"
            BITFLD.QUAD 0x00 0.--4. "Rsvd_CFG    ,Rsvd_CFG"
    GROUP.QUAD 0x48++0x8
        LINE.QUAD 0x00 "SGR,Source Gather Register for Channel 2"
            BITFLD.QUAD 0x00 20.--50. "SGC    ,SGC"
            BITFLD.QUAD 0x00 0.--19. "SGI    ,SGI"
    GROUP.QUAD 0x50++0x8
        LINE.QUAD 0x00 "DSR,Destination Scatter Register for Channel 2"
            BITFLD.QUAD 0x00 20.--50. "DSC    ,DSC"
            BITFLD.QUAD 0x00 0.--19. "DSI    ,DSI"
TREE.END	
    
TREE "Channel 3"
	BASE ad:0xC20108
	GROUP.QUAD 0x0++0x8
        LINE.QUAD 0x00 "SAR,Source Address for Channel 3"
            BITFLD.QUAD 0x00 0.--31. "SAR    ,SAR"
    GROUP.QUAD 0x8++0x8
        LINE.QUAD 0x00 "DAR,Destination Address Register for Channel 3"
            BITFLD.QUAD 0x00 0.--31. "DAR    ,DAR"
    GROUP.QUAD 0x10++0x8
        LINE.QUAD 0x00 "LLP,Linked List Pointer Register for Channel 3"
            BITFLD.QUAD 0x00 2.--31. "LOC    ,LOC"
            BITFLD.QUAD 0x00 0.--1. "LMS    ,LMS" "0,1,2,3"
	GROUP.QUAD 0x18++0x8
        LINE.QUAD 0x00 "CTL,Control Register for Channel 3"
            BITFLD.QUAD 0x00 44. "DONE    ,DONE" "0,1"
            BITFLD.QUAD 0x00 37.--43. "Rsvd_2_CTL    ,Rsvd_2_CTL"
            BITFLD.QUAD 0x00 32.--36. "BLOCK_TS    ,BLOCK_TS"
            BITFLD.QUAD 0x00 29.--31. "Rsvd_1_CTL    ,Rsvd_1_CTL"
            NEWLINE
            BITFLD.QUAD 0x00 28. "LLP_SRC_EN    ,LLP_SRC_EN" "0,1"
            BITFLD.QUAD 0x00 27. "LLP_DST_EN    ,LLP_DST_EN" "0,1"
            BITFLD.QUAD 0x00 25.--26. "SMS    ,SMS" "0,1,2,3"
            BITFLD.QUAD 0x00 23.--24. "DMS    ,DMS" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 20.--22. "TT_FC    ,TT_FC"
            BITFLD.QUAD 0x00 19. "Rsvd_CTL    ,Rsvd_CTL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_SCATTER_EN    ,DST_SCATTER_EN" "0,1"
            BITFLD.QUAD 0x00 17. "SRC_GATHER_EN    ,SRC_GATHER_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 14.--16. "SRC_MSIZE    ,SRC_MSIZE"
            BITFLD.QUAD 0x00 11.--13. "DEST_MSIZE    ,DEST_MSIZE"
            BITFLD.QUAD 0x00 9.--10. "SINC    ,SINC" "0,1,2,3"
            BITFLD.QUAD 0x00 7.--8. "DINC    ,DINC" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 4.--6. "SRC_TR_WIDTH    ,SRC_TR_WIDTH"
            BITFLD.QUAD 0x00 1.--3. "DST_TR_WIDTH    ,DST_TR_WIDTH"
            BITFLD.QUAD 0x00 0. "INT_EN    ,INT_EN" "0,1"
    GROUP.QUAD 0x20++0x8
        LINE.QUAD 0x00 "SSTAT,Source Status Register for Channel 3"
            BITFLD.QUAD 0x00 0.--31. "SSTAT    ,SSTAT"
    GROUP.QUAD 0x28++0x8
        LINE.QUAD 0x00 "DSTAT,Destination Status Register for Channel 3"
            BITFLD.QUAD 0x00 0.--31. "DSTAT    ,DSTAT"
    GROUP.QUAD 0x30++0x8
        LINE.QUAD 0x00 "SSTATR,Source Status Address Register for Channel 3"
            BITFLD.QUAD 0x00 0.--31. "SSTATAR    ,SSTATAR"
    GROUP.QUAD 0x38++0x8
        LINE.QUAD 0x00 "DSTATAR,Destination Status Address Register for Channel 3"
            BITFLD.QUAD 0x00 0.--31. "DSTATAR    ,DSTATAR"
	GROUP.QUAD 0x40++0x8
        LINE.QUAD 0x00 "CFG,Configuration Register for Channel 3"
            BITFLD.QUAD 0x00 43.--46. "DEST_PER    ,DEST_PER"
            BITFLD.QUAD 0x00 39.--42. "SRC_PER    ,SRC_PER"
            BITFLD.QUAD 0x00 38. "SS_UPD_EN    ,SS_UPD_EN" "0,1"
            BITFLD.QUAD 0x00 37. "DS_UPD_EN    ,DS_UPD_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 34.--36. "PROTCTL    ,PROTCTL"
            BITFLD.QUAD 0x00 33. "FIFO_MODE    ,FIFO_MODE" "0,1"
            BITFLD.QUAD 0x00 32. "FCMODE    ,FCMODE" "0,1"
            BITFLD.QUAD 0x00 31. "RELOAD_DST    ,RELOAD_DST" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 30. "RELOAD_SRC    ,RELOAD_SRC" "0,1"
            BITFLD.QUAD 0x00 20.--29. "Rsvd2_CFG    ,Rsvd2_CFG"
            BITFLD.QUAD 0x00 19. "SRC_HS_POL    ,SRC_HS_POL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_HS_POL    ,DST_HS_POL" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 12.--17. "Rsvd1_CFG    ,Rsvd1_CFG"
            BITFLD.QUAD 0x00 11. "HS_SEL_SRC    ,HS_SEL_SRC" "0,1"
            BITFLD.QUAD 0x00 10. "HS_SEL_DST    ,HS_SEL_DST" "0,1"
            BITFLD.QUAD 0x00 9. "FIFO_EMPTY    ,FIFO_EMPTY" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 8. "CH_SUSP    ,CH_SUSP" "0,1"
            BITFLD.QUAD 0x00 5.--7. "CH_PRIOR    ,CH_PRIOR"
            BITFLD.QUAD 0x00 0.--4. "Rsvd_CFG    ,Rsvd_CFG"
    GROUP.QUAD 0x48++0x8
        LINE.QUAD 0x00 "SGR,Source Gather Register for Channel 3"
            BITFLD.QUAD 0x00 20.--50. "SGC    ,SGC"
            BITFLD.QUAD 0x00 0.--19. "SGI    ,SGI"
    GROUP.QUAD 0x50++0x8
        LINE.QUAD 0x00 "DSR,Destination Scatter Register for Channel 3"
            BITFLD.QUAD 0x00 20.--50. "DSC    ,DSC"
            BITFLD.QUAD 0x00 0.--19. "DSI    ,DSI"
TREE.END	
    
TREE "Channel 4"
	BASE ad:0xC20160
	GROUP.QUAD 0x0++0x8
        LINE.QUAD 0x00 "SAR,Source Address for Channel 4"
            BITFLD.QUAD 0x00 0.--31. "SAR    ,SAR"
    GROUP.QUAD 0x8++0x8
        LINE.QUAD 0x00 "DAR,Destination Address Register for Channel 4"
            BITFLD.QUAD 0x00 0.--31. "DAR    ,DAR"
    GROUP.QUAD 0x10++0x8
        LINE.QUAD 0x00 "LLP,Linked List Pointer Register for Channel 4"
            BITFLD.QUAD 0x00 2.--31. "LOC    ,LOC"
            BITFLD.QUAD 0x00 0.--1. "LMS    ,LMS" "0,1,2,3"
	GROUP.QUAD 0x18++0x8
        LINE.QUAD 0x00 "CTL,Control Register for Channel 4"
            BITFLD.QUAD 0x00 44. "DONE    ,DONE" "0,1"
            BITFLD.QUAD 0x00 37.--43. "Rsvd_2_CTL    ,Rsvd_2_CTL"
            BITFLD.QUAD 0x00 32.--36. "BLOCK_TS    ,BLOCK_TS"
            BITFLD.QUAD 0x00 29.--31. "Rsvd_1_CTL    ,Rsvd_1_CTL"
            NEWLINE
            BITFLD.QUAD 0x00 28. "LLP_SRC_EN    ,LLP_SRC_EN" "0,1"
            BITFLD.QUAD 0x00 27. "LLP_DST_EN    ,LLP_DST_EN" "0,1"
            BITFLD.QUAD 0x00 25.--26. "SMS    ,SMS" "0,1,2,3"
            BITFLD.QUAD 0x00 23.--24. "DMS    ,DMS" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 20.--22. "TT_FC    ,TT_FC"
            BITFLD.QUAD 0x00 19. "Rsvd_CTL    ,Rsvd_CTL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_SCATTER_EN    ,DST_SCATTER_EN" "0,1"
            BITFLD.QUAD 0x00 17. "SRC_GATHER_EN    ,SRC_GATHER_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 14.--16. "SRC_MSIZE    ,SRC_MSIZE"
            BITFLD.QUAD 0x00 11.--13. "DEST_MSIZE    ,DEST_MSIZE"
            BITFLD.QUAD 0x00 9.--10. "SINC    ,SINC" "0,1,2,3"
            BITFLD.QUAD 0x00 7.--8. "DINC    ,DINC" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 4.--6. "SRC_TR_WIDTH    ,SRC_TR_WIDTH"
            BITFLD.QUAD 0x00 1.--3. "DST_TR_WIDTH    ,DST_TR_WIDTH"
            BITFLD.QUAD 0x00 0. "INT_EN    ,INT_EN" "0,1"
    GROUP.QUAD 0x20++0x8
        LINE.QUAD 0x00 "SSTAT,Source Status Register for Channel 4"
            BITFLD.QUAD 0x00 0.--31. "SSTAT    ,SSTAT"
    GROUP.QUAD 0x28++0x8
        LINE.QUAD 0x00 "DSTAT,Destination Status Register for Channel 4"
            BITFLD.QUAD 0x00 0.--31. "DSTAT    ,DSTAT"
    GROUP.QUAD 0x30++0x8
        LINE.QUAD 0x00 "SSTATR,Source Status Address Register for Channel 4"
            BITFLD.QUAD 0x00 0.--31. "SSTATAR    ,SSTATAR"
    GROUP.QUAD 0x38++0x8
        LINE.QUAD 0x00 "DSTATAR,Destination Status Address Register for Channel 4"
            BITFLD.QUAD 0x00 0.--31. "DSTATAR    ,DSTATAR"
	GROUP.QUAD 0x40++0x8
        LINE.QUAD 0x00 "CFG,Configuration Register for Channel 4"
            BITFLD.QUAD 0x00 43.--46. "DEST_PER    ,DEST_PER"
            BITFLD.QUAD 0x00 39.--42. "SRC_PER    ,SRC_PER"
            BITFLD.QUAD 0x00 38. "SS_UPD_EN    ,SS_UPD_EN" "0,1"
            BITFLD.QUAD 0x00 37. "DS_UPD_EN    ,DS_UPD_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 34.--36. "PROTCTL    ,PROTCTL"
            BITFLD.QUAD 0x00 33. "FIFO_MODE    ,FIFO_MODE" "0,1"
            BITFLD.QUAD 0x00 32. "FCMODE    ,FCMODE" "0,1"
            BITFLD.QUAD 0x00 31. "RELOAD_DST    ,RELOAD_DST" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 30. "RELOAD_SRC    ,RELOAD_SRC" "0,1"
            BITFLD.QUAD 0x00 20.--29. "Rsvd2_CFG    ,Rsvd2_CFG"
            BITFLD.QUAD 0x00 19. "SRC_HS_POL    ,SRC_HS_POL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_HS_POL    ,DST_HS_POL" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 12.--17. "Rsvd1_CFG    ,Rsvd1_CFG"
            BITFLD.QUAD 0x00 11. "HS_SEL_SRC    ,HS_SEL_SRC" "0,1"
            BITFLD.QUAD 0x00 10. "HS_SEL_DST    ,HS_SEL_DST" "0,1"
            BITFLD.QUAD 0x00 9. "FIFO_EMPTY    ,FIFO_EMPTY" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 8. "CH_SUSP    ,CH_SUSP" "0,1"
            BITFLD.QUAD 0x00 5.--7. "CH_PRIOR    ,CH_PRIOR"
            BITFLD.QUAD 0x00 0.--4. "Rsvd_CFG    ,Rsvd_CFG"
    GROUP.QUAD 0x48++0x8
        LINE.QUAD 0x00 "SGR,Source Gather Register for Channel 4"
            BITFLD.QUAD 0x00 20.--50. "SGC    ,SGC"
            BITFLD.QUAD 0x00 0.--19. "SGI    ,SGI"
    GROUP.QUAD 0x50++0x8
        LINE.QUAD 0x00 "DSR,Destination Scatter Register for Channel 4"
            BITFLD.QUAD 0x00 20.--50. "DSC    ,DSC"
            BITFLD.QUAD 0x00 0.--19. "DSI    ,DSI"
TREE.END	
    
TREE "Channel 5"
	BASE ad:0xC201B8
	GROUP.QUAD 0x0++0x8
        LINE.QUAD 0x00 "SAR,Source Address for Channel 5"
            BITFLD.QUAD 0x00 0.--31. "SAR    ,SAR"
    GROUP.QUAD 0x8++0x8
        LINE.QUAD 0x00 "DAR,Destination Address Register for Channel 5"
            BITFLD.QUAD 0x00 0.--31. "DAR    ,DAR"
    GROUP.QUAD 0x10++0x8
        LINE.QUAD 0x00 "LLP,Linked List Pointer Register for Channel 5"
            BITFLD.QUAD 0x00 2.--31. "LOC    ,LOC"
            BITFLD.QUAD 0x00 0.--1. "LMS    ,LMS" "0,1,2,3"
	GROUP.QUAD 0x18++0x8
        LINE.QUAD 0x00 "CTL,Control Register for Channel 5"
            BITFLD.QUAD 0x00 44. "DONE    ,DONE" "0,1"
            BITFLD.QUAD 0x00 37.--43. "Rsvd_2_CTL    ,Rsvd_2_CTL"
            BITFLD.QUAD 0x00 32.--36. "BLOCK_TS    ,BLOCK_TS"
            BITFLD.QUAD 0x00 29.--31. "Rsvd_1_CTL    ,Rsvd_1_CTL"
            NEWLINE
            BITFLD.QUAD 0x00 28. "LLP_SRC_EN    ,LLP_SRC_EN" "0,1"
            BITFLD.QUAD 0x00 27. "LLP_DST_EN    ,LLP_DST_EN" "0,1"
            BITFLD.QUAD 0x00 25.--26. "SMS    ,SMS" "0,1,2,3"
            BITFLD.QUAD 0x00 23.--24. "DMS    ,DMS" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 20.--22. "TT_FC    ,TT_FC"
            BITFLD.QUAD 0x00 19. "Rsvd_CTL    ,Rsvd_CTL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_SCATTER_EN    ,DST_SCATTER_EN" "0,1"
            BITFLD.QUAD 0x00 17. "SRC_GATHER_EN    ,SRC_GATHER_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 14.--16. "SRC_MSIZE    ,SRC_MSIZE"
            BITFLD.QUAD 0x00 11.--13. "DEST_MSIZE    ,DEST_MSIZE"
            BITFLD.QUAD 0x00 9.--10. "SINC    ,SINC" "0,1,2,3"
            BITFLD.QUAD 0x00 7.--8. "DINC    ,DINC" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 4.--6. "SRC_TR_WIDTH    ,SRC_TR_WIDTH"
            BITFLD.QUAD 0x00 1.--3. "DST_TR_WIDTH    ,DST_TR_WIDTH"
            BITFLD.QUAD 0x00 0. "INT_EN    ,INT_EN" "0,1"
    GROUP.QUAD 0x20++0x8
        LINE.QUAD 0x00 "SSTAT,Source Status Register for Channel 5"
            BITFLD.QUAD 0x00 0.--31. "SSTAT    ,SSTAT"
    GROUP.QUAD 0x28++0x8
        LINE.QUAD 0x00 "DSTAT,Destination Status Register for Channel 5"
            BITFLD.QUAD 0x00 0.--31. "DSTAT    ,DSTAT"
    GROUP.QUAD 0x30++0x8
        LINE.QUAD 0x00 "SSTATR,Source Status Address Register for Channel 5"
            BITFLD.QUAD 0x00 0.--31. "SSTATAR    ,SSTATAR"
    GROUP.QUAD 0x38++0x8
        LINE.QUAD 0x00 "DSTATAR,Destination Status Address Register for Channel 5"
            BITFLD.QUAD 0x00 0.--31. "DSTATAR    ,DSTATAR"
	GROUP.QUAD 0x40++0x8
        LINE.QUAD 0x00 "CFG,Configuration Register for Channel 5"
            BITFLD.QUAD 0x00 43.--46. "DEST_PER    ,DEST_PER"
            BITFLD.QUAD 0x00 39.--42. "SRC_PER    ,SRC_PER"
            BITFLD.QUAD 0x00 38. "SS_UPD_EN    ,SS_UPD_EN" "0,1"
            BITFLD.QUAD 0x00 37. "DS_UPD_EN    ,DS_UPD_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 34.--36. "PROTCTL    ,PROTCTL"
            BITFLD.QUAD 0x00 33. "FIFO_MODE    ,FIFO_MODE" "0,1"
            BITFLD.QUAD 0x00 32. "FCMODE    ,FCMODE" "0,1"
            BITFLD.QUAD 0x00 31. "RELOAD_DST    ,RELOAD_DST" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 30. "RELOAD_SRC    ,RELOAD_SRC" "0,1"
            BITFLD.QUAD 0x00 20.--29. "Rsvd2_CFG    ,Rsvd2_CFG"
            BITFLD.QUAD 0x00 19. "SRC_HS_POL    ,SRC_HS_POL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_HS_POL    ,DST_HS_POL" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 12.--17. "Rsvd1_CFG    ,Rsvd1_CFG"
            BITFLD.QUAD 0x00 11. "HS_SEL_SRC    ,HS_SEL_SRC" "0,1"
            BITFLD.QUAD 0x00 10. "HS_SEL_DST    ,HS_SEL_DST" "0,1"
            BITFLD.QUAD 0x00 9. "FIFO_EMPTY    ,FIFO_EMPTY" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 8. "CH_SUSP    ,CH_SUSP" "0,1"
            BITFLD.QUAD 0x00 5.--7. "CH_PRIOR    ,CH_PRIOR"
            BITFLD.QUAD 0x00 0.--4. "Rsvd_CFG    ,Rsvd_CFG"
    GROUP.QUAD 0x48++0x8
        LINE.QUAD 0x00 "SGR,Source Gather Register for Channel 5"
            BITFLD.QUAD 0x00 20.--50. "SGC    ,SGC"
            BITFLD.QUAD 0x00 0.--19. "SGI    ,SGI"
    GROUP.QUAD 0x50++0x8
        LINE.QUAD 0x00 "DSR,Destination Scatter Register for Channel 5"
            BITFLD.QUAD 0x00 20.--50. "DSC    ,DSC"
            BITFLD.QUAD 0x00 0.--19. "DSI    ,DSI"
TREE.END	
    
TREE "Channel 6"
	BASE ad:0xC20210
	GROUP.QUAD 0x0++0x8
        LINE.QUAD 0x00 "SAR,Source Address for Channel 6"
            BITFLD.QUAD 0x00 0.--31. "SAR    ,SAR"
    GROUP.QUAD 0x8++0x8
        LINE.QUAD 0x00 "DAR,Destination Address Register for Channel 6"
            BITFLD.QUAD 0x00 0.--31. "DAR    ,DAR"
    GROUP.QUAD 0x10++0x8
        LINE.QUAD 0x00 "LLP,Linked List Pointer Register for Channel 6"
            BITFLD.QUAD 0x00 2.--31. "LOC    ,LOC"
            BITFLD.QUAD 0x00 0.--1. "LMS    ,LMS" "0,1,2,3"
	GROUP.QUAD 0x18++0x8
        LINE.QUAD 0x00 "CTL,Control Register for Channel 6"
            BITFLD.QUAD 0x00 44. "DONE    ,DONE" "0,1"
            BITFLD.QUAD 0x00 37.--43. "Rsvd_2_CTL    ,Rsvd_2_CTL"
            BITFLD.QUAD 0x00 32.--36. "BLOCK_TS    ,BLOCK_TS"
            BITFLD.QUAD 0x00 29.--31. "Rsvd_1_CTL    ,Rsvd_1_CTL"
            NEWLINE
            BITFLD.QUAD 0x00 28. "LLP_SRC_EN    ,LLP_SRC_EN" "0,1"
            BITFLD.QUAD 0x00 27. "LLP_DST_EN    ,LLP_DST_EN" "0,1"
            BITFLD.QUAD 0x00 25.--26. "SMS    ,SMS" "0,1,2,3"
            BITFLD.QUAD 0x00 23.--24. "DMS    ,DMS" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 20.--22. "TT_FC    ,TT_FC"
            BITFLD.QUAD 0x00 19. "Rsvd_CTL    ,Rsvd_CTL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_SCATTER_EN    ,DST_SCATTER_EN" "0,1"
            BITFLD.QUAD 0x00 17. "SRC_GATHER_EN    ,SRC_GATHER_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 14.--16. "SRC_MSIZE    ,SRC_MSIZE"
            BITFLD.QUAD 0x00 11.--13. "DEST_MSIZE    ,DEST_MSIZE"
            BITFLD.QUAD 0x00 9.--10. "SINC    ,SINC" "0,1,2,3"
            BITFLD.QUAD 0x00 7.--8. "DINC    ,DINC" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 4.--6. "SRC_TR_WIDTH    ,SRC_TR_WIDTH"
            BITFLD.QUAD 0x00 1.--3. "DST_TR_WIDTH    ,DST_TR_WIDTH"
            BITFLD.QUAD 0x00 0. "INT_EN    ,INT_EN" "0,1"
    GROUP.QUAD 0x20++0x8
        LINE.QUAD 0x00 "SSTAT,Source Status Register for Channel 6"
            BITFLD.QUAD 0x00 0.--31. "SSTAT    ,SSTAT"
    GROUP.QUAD 0x28++0x8
        LINE.QUAD 0x00 "DSTAT,Destination Status Register for Channel 6"
            BITFLD.QUAD 0x00 0.--31. "DSTAT    ,DSTAT"
    GROUP.QUAD 0x30++0x8
        LINE.QUAD 0x00 "SSTATR,Source Status Address Register for Channel 6"
            BITFLD.QUAD 0x00 0.--31. "SSTATAR    ,SSTATAR"
    GROUP.QUAD 0x38++0x8
        LINE.QUAD 0x00 "DSTATAR,Destination Status Address Register for Channel 6"
            BITFLD.QUAD 0x00 0.--31. "DSTATAR    ,DSTATAR"
	GROUP.QUAD 0x40++0x8
        LINE.QUAD 0x00 "CFG,Configuration Register for Channel 6"
            BITFLD.QUAD 0x00 43.--46. "DEST_PER    ,DEST_PER"
            BITFLD.QUAD 0x00 39.--42. "SRC_PER    ,SRC_PER"
            BITFLD.QUAD 0x00 38. "SS_UPD_EN    ,SS_UPD_EN" "0,1"
            BITFLD.QUAD 0x00 37. "DS_UPD_EN    ,DS_UPD_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 34.--36. "PROTCTL    ,PROTCTL"
            BITFLD.QUAD 0x00 33. "FIFO_MODE    ,FIFO_MODE" "0,1"
            BITFLD.QUAD 0x00 32. "FCMODE    ,FCMODE" "0,1"
            BITFLD.QUAD 0x00 31. "RELOAD_DST    ,RELOAD_DST" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 30. "RELOAD_SRC    ,RELOAD_SRC" "0,1"
            BITFLD.QUAD 0x00 20.--29. "Rsvd2_CFG    ,Rsvd2_CFG"
            BITFLD.QUAD 0x00 19. "SRC_HS_POL    ,SRC_HS_POL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_HS_POL    ,DST_HS_POL" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 12.--17. "Rsvd1_CFG    ,Rsvd1_CFG"
            BITFLD.QUAD 0x00 11. "HS_SEL_SRC    ,HS_SEL_SRC" "0,1"
            BITFLD.QUAD 0x00 10. "HS_SEL_DST    ,HS_SEL_DST" "0,1"
            BITFLD.QUAD 0x00 9. "FIFO_EMPTY    ,FIFO_EMPTY" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 8. "CH_SUSP    ,CH_SUSP" "0,1"
            BITFLD.QUAD 0x00 5.--7. "CH_PRIOR    ,CH_PRIOR"
            BITFLD.QUAD 0x00 0.--4. "Rsvd_CFG    ,Rsvd_CFG"
    GROUP.QUAD 0x48++0x8
        LINE.QUAD 0x00 "SGR,Source Gather Register for Channel 6"
            BITFLD.QUAD 0x00 20.--50. "SGC    ,SGC"
            BITFLD.QUAD 0x00 0.--19. "SGI    ,SGI"
    GROUP.QUAD 0x50++0x8
        LINE.QUAD 0x00 "DSR,Destination Scatter Register for Channel 6"
            BITFLD.QUAD 0x00 20.--50. "DSC    ,DSC"
            BITFLD.QUAD 0x00 0.--19. "DSI    ,DSI"
TREE.END	
    
TREE "Channel 7"
	BASE ad:0xC20268
	GROUP.QUAD 0x0++0x8
        LINE.QUAD 0x00 "SAR,Source Address for Channel 7"
            BITFLD.QUAD 0x00 0.--31. "SAR    ,SAR"
    GROUP.QUAD 0x8++0x8
        LINE.QUAD 0x00 "DAR,Destination Address Register for Channel 7"
            BITFLD.QUAD 0x00 0.--31. "DAR    ,DAR"
    GROUP.QUAD 0x10++0x8
        LINE.QUAD 0x00 "LLP,Linked List Pointer Register for Channel 7"
            BITFLD.QUAD 0x00 2.--31. "LOC    ,LOC"
            BITFLD.QUAD 0x00 0.--1. "LMS    ,LMS" "0,1,2,3"
	GROUP.QUAD 0x18++0x8
        LINE.QUAD 0x00 "CTL,Control Register for Channel 7"
            BITFLD.QUAD 0x00 44. "DONE    ,DONE" "0,1"
            BITFLD.QUAD 0x00 37.--43. "Rsvd_2_CTL    ,Rsvd_2_CTL"
            BITFLD.QUAD 0x00 32.--36. "BLOCK_TS    ,BLOCK_TS"
            BITFLD.QUAD 0x00 29.--31. "Rsvd_1_CTL    ,Rsvd_1_CTL"
            NEWLINE
            BITFLD.QUAD 0x00 28. "LLP_SRC_EN    ,LLP_SRC_EN" "0,1"
            BITFLD.QUAD 0x00 27. "LLP_DST_EN    ,LLP_DST_EN" "0,1"
            BITFLD.QUAD 0x00 25.--26. "SMS    ,SMS" "0,1,2,3"
            BITFLD.QUAD 0x00 23.--24. "DMS    ,DMS" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 20.--22. "TT_FC    ,TT_FC"
            BITFLD.QUAD 0x00 19. "Rsvd_CTL    ,Rsvd_CTL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_SCATTER_EN    ,DST_SCATTER_EN" "0,1"
            BITFLD.QUAD 0x00 17. "SRC_GATHER_EN    ,SRC_GATHER_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 14.--16. "SRC_MSIZE    ,SRC_MSIZE"
            BITFLD.QUAD 0x00 11.--13. "DEST_MSIZE    ,DEST_MSIZE"
            BITFLD.QUAD 0x00 9.--10. "SINC    ,SINC" "0,1,2,3"
            BITFLD.QUAD 0x00 7.--8. "DINC    ,DINC" "0,1,2,3"
            NEWLINE
            BITFLD.QUAD 0x00 4.--6. "SRC_TR_WIDTH    ,SRC_TR_WIDTH"
            BITFLD.QUAD 0x00 1.--3. "DST_TR_WIDTH    ,DST_TR_WIDTH"
            BITFLD.QUAD 0x00 0. "INT_EN    ,INT_EN" "0,1"
    GROUP.QUAD 0x20++0x8
        LINE.QUAD 0x00 "SSTAT,Source Status Register for Channel 7"
            BITFLD.QUAD 0x00 0.--31. "SSTAT    ,SSTAT"
    GROUP.QUAD 0x28++0x8
        LINE.QUAD 0x00 "DSTAT,Destination Status Register for Channel 7"
            BITFLD.QUAD 0x00 0.--31. "DSTAT    ,DSTAT"
    GROUP.QUAD 0x30++0x8
        LINE.QUAD 0x00 "SSTATR,Source Status Address Register for Channel 7"
            BITFLD.QUAD 0x00 0.--31. "SSTATAR    ,SSTATAR"
    GROUP.QUAD 0x38++0x8
        LINE.QUAD 0x00 "DSTATAR,Destination Status Address Register for Channel 7"
            BITFLD.QUAD 0x00 0.--31. "DSTATAR    ,DSTATAR"
	GROUP.QUAD 0x40++0x8
        LINE.QUAD 0x00 "CFG,Configuration Register for Channel 7"
            BITFLD.QUAD 0x00 43.--46. "DEST_PER    ,DEST_PER"
            BITFLD.QUAD 0x00 39.--42. "SRC_PER    ,SRC_PER"
            BITFLD.QUAD 0x00 38. "SS_UPD_EN    ,SS_UPD_EN" "0,1"
            BITFLD.QUAD 0x00 37. "DS_UPD_EN    ,DS_UPD_EN" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 34.--36. "PROTCTL    ,PROTCTL"
            BITFLD.QUAD 0x00 33. "FIFO_MODE    ,FIFO_MODE" "0,1"
            BITFLD.QUAD 0x00 32. "FCMODE    ,FCMODE" "0,1"
            BITFLD.QUAD 0x00 31. "RELOAD_DST    ,RELOAD_DST" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 30. "RELOAD_SRC    ,RELOAD_SRC" "0,1"
            BITFLD.QUAD 0x00 20.--29. "Rsvd2_CFG    ,Rsvd2_CFG"
            BITFLD.QUAD 0x00 19. "SRC_HS_POL    ,SRC_HS_POL" "0,1"
            BITFLD.QUAD 0x00 18. "DST_HS_POL    ,DST_HS_POL" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 12.--17. "Rsvd1_CFG    ,Rsvd1_CFG"
            BITFLD.QUAD 0x00 11. "HS_SEL_SRC    ,HS_SEL_SRC" "0,1"
            BITFLD.QUAD 0x00 10. "HS_SEL_DST    ,HS_SEL_DST" "0,1"
            BITFLD.QUAD 0x00 9. "FIFO_EMPTY    ,FIFO_EMPTY" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 8. "CH_SUSP    ,CH_SUSP" "0,1"
            BITFLD.QUAD 0x00 5.--7. "CH_PRIOR    ,CH_PRIOR"
            BITFLD.QUAD 0x00 0.--4. "Rsvd_CFG    ,Rsvd_CFG"
    GROUP.QUAD 0x48++0x8
        LINE.QUAD 0x00 "SGR,Source Gather Register for Channel 7"
            BITFLD.QUAD 0x00 20.--50. "SGC    ,SGC"
            BITFLD.QUAD 0x00 0.--19. "SGI    ,SGI"
    GROUP.QUAD 0x50++0x8
        LINE.QUAD 0x00 "DSR,Destination Scatter Register for Channel 7"
            BITFLD.QUAD 0x00 20.--50. "DSC    ,DSC"
            BITFLD.QUAD 0x00 0.--19. "DSI    ,DSI"
TREE.END	
    
TREE "RAW STATUS"
	BASE ad:0xC20000
	GROUP.QUAD 0x2c0++0x8
        LINE.QUAD 0x00 "RawTfr,Raw Status for IntTfr Interrupt"
            BITFLD.QUAD 0x00 0.--7. "RAW    ,RAW"
    GROUP.QUAD 0x2c8++0x8
        LINE.QUAD 0x00 "RawBlock,Raw Status for IntBlock Interrupt"
            BITFLD.QUAD 0x00 0.--7. "RAW    ,RAW"
    GROUP.QUAD 0x2d0++0x8
        LINE.QUAD 0x00 "RawSrcTran,Raw Status for IntSrcTran Interrupt"
            BITFLD.QUAD 0x00 0.--7. "RAW    ,RAW"
    GROUP.QUAD 0x2d8++0x8
        LINE.QUAD 0x00 "RawDstTran,Raw Status for IntDstTran Interrupt"
            BITFLD.QUAD 0x00 0.--7. "RAW    ,RAW"
    GROUP.QUAD 0x2e0++0x8
        LINE.QUAD 0x00 "RawErr,Raw Status for IntErr Interrupt"
            BITFLD.QUAD 0x00 0.--7. "RAW    ,RAW"
    GROUP.QUAD 0x2e8++0x8
        LINE.QUAD 0x00 "StatusTfr,Status for IntTfr Interrupt"
            BITFLD.QUAD 0x00 0.--7. "STATUS    ,STATUS"
    GROUP.QUAD 0x2f0++0x8
        LINE.QUAD 0x00 "StatusBlock,Status for IntBlock Interrupt"
            BITFLD.QUAD 0x00 0.--7. "STATUS    ,STATUS"
    GROUP.QUAD 0x2f8++0x8
        LINE.QUAD 0x00 "StatusSrcTran,Status for IntSrcTran Interrupt"
            BITFLD.QUAD 0x00 0.--7. "STATUS    ,STATUS"
    GROUP.QUAD 0x300++0x8
        LINE.QUAD 0x00 "StatusDstTran,Status for IntDstTran Interrupt"
            BITFLD.QUAD 0x00 0.--7. "STATUS    ,STATUS"
    GROUP.QUAD 0x308++0x8
        LINE.QUAD 0x00 "StatusErr,Status for IntErr Interrupt"
            BITFLD.QUAD 0x00 0.--7. "STATUS    ,STATUS"
    GROUP.QUAD 0x310++0x8
        LINE.QUAD 0x00 "MaskTfr,Status for IntTfr Interrupt"
            BITFLD.QUAD 0x00 8.--15. "INT_MASK_WE    ,INT_MASK_WE"
            BITFLD.QUAD 0x00 0.--7. "INT_MASK    ,INT_MASK"
    GROUP.QUAD 0x318++0x8
        LINE.QUAD 0x00 "MaskBlock,Mask for IntBlock Interrupt"
            BITFLD.QUAD 0x00 8.--15. "INT_MASK_WE    ,INT_MASK_WE"
            BITFLD.QUAD 0x00 0.--7. "INT_MASK    ,INT_MASK"
    GROUP.QUAD 0x320++0x8
        LINE.QUAD 0x00 "MaskSrcTran,Status for IntSrcTran Interrupt"
            BITFLD.QUAD 0x00 8.--15. "INT_MASK_WE    ,INT_MASK_WE"
            BITFLD.QUAD 0x00 0.--7. "INT_MASK    ,INT_MASK"
    GROUP.QUAD 0X328++0x8
        LINE.QUAD 0x00 "MaskDstTran,Mask for IntDstTran Interrupt"
            BITFLD.QUAD 0x00 8.--15. "INT_MASK_WE    ,INT_MASK_WE"
            BITFLD.QUAD 0x00 0.--7. "INT_MASK    ,INT_MASK"
    GROUP.QUAD 0x330++0x8
        LINE.QUAD 0x00 "MaskErr,Mask for IntErr Interrupt"
            BITFLD.QUAD 0x00 8.--15. "INT_MASK_WE    ,INT_MASK_WE"
            BITFLD.QUAD 0x00 0.--7. "INT_MASK    ,INT_MASK"
    GROUP.QUAD 0x338++0x8
        LINE.QUAD 0x00 "ClearTfr,Clear for IntTfr Interrupt"
            BITFLD.QUAD 0x00 0.--7. "CLEAR    ,CLEAR"
    GROUP.QUAD 0x340++0x8
        LINE.QUAD 0x00 "ClearBlock,Clear for IntBlock Interrupt"
            BITFLD.QUAD 0x00 0.--7. "CLEAR    ,CLEAR"
    GROUP.QUAD 0x348++0x8
        LINE.QUAD 0x00 "ClearSrcTran,Clear for IntSrcTran Interrupt"
            BITFLD.QUAD 0x00 0.--7. "CLEAR    ,CLEAR"
    GROUP.QUAD 0x350++0x8
        LINE.QUAD 0x00 "ClearDstTran,Clear for IntDstTran Interrupt"
            BITFLD.QUAD 0x00 0.--7. "CLEAR    ,CLEAR"
    GROUP.QUAD 0x358++0x8
        LINE.QUAD 0x00 "ClearErr,Clear for IntErr Interrupt"
            BITFLD.QUAD 0x00 0.--7. "CLEAR    ,CLEAR"
    GROUP.QUAD 0x360++0x8
        LINE.QUAD 0x00 "StatusInt,Status for each Interrupt type"
            BITFLD.QUAD 0x00 4. "ERR    ,ERR" "0,1"
            BITFLD.QUAD 0x00 3. "DSTT    ,DSTT" "0,1"
            BITFLD.QUAD 0x00 2. "SRCT    ,SRCT" "0,1"
            BITFLD.QUAD 0x00 1. "BLOCK    ,BLOCK" "0,1"
            NEWLINE
            BITFLD.QUAD 0x00 0. "TFR    ,TFR" "0,1"
    GROUP.QUAD 0x368++0x8
        LINE.QUAD 0x00 "ReqSrcReg,Source Software Transaction Request register"
            BITFLD.QUAD 0x00 8.--15. "SRC_REQ_WE    ,SRC_REQ_WE"
            BITFLD.QUAD 0x00 0.--7. "SRC_REQ    ,SRC_REQ"
    GROUP.QUAD 0x370++0x8
        LINE.QUAD 0x00 "ReqDstReg,Destination Software Transaction Request register"
            BITFLD.QUAD 0x00 8.--15. "DST_REQ_WE    ,DST_REQ_WE"
            BITFLD.QUAD 0x00 0.--7. "DST_REQ    ,DST_REQ"
    GROUP.QUAD 0x378++0x8
        LINE.QUAD 0x00 "SglRqSrcReg,Source Single Transaction Request register"
            BITFLD.QUAD 0x00 8.--15. "SRC_SGLREQ_WE    ,SRC_SGLREQ_WE"
            BITFLD.QUAD 0x00 0.--7. "SRC_SGLREQ    ,SRC_SGLREQ"
    GROUP.QUAD 0x380++0x8
        LINE.QUAD 0x00 "SglRqDstReg,Destination Single Transaction Request register"
            BITFLD.QUAD 0x00 8.--15. "DST_SGLREQ_WE    ,DST_SGLREQ_WE"
            BITFLD.QUAD 0x00 0.--7. "DST_SGLREQ    ,DST_SGLREQ"
    GROUP.QUAD 0x388++0x8
        LINE.QUAD 0x00 "LstSrcReg,Source Last Transaction Request register"
            BITFLD.QUAD 0x00 8.--15. "LSTSRC_WE    ,LSTSRC_WE"
            BITFLD.QUAD 0x00 0.--7. "LSTSRC    ,LSTSRC"
    GROUP.QUAD 0x390++0x8
        LINE.QUAD 0x00 "LstDstReg,Destination Last Transaction Request register"
            BITFLD.QUAD 0x00 8.--15. "LSTDST_WE    ,LSTDST_WE"
            BITFLD.QUAD 0x00 0.--7. "LSTDST    ,LSTDST"
    GROUP.QUAD 0x398++0x8
        LINE.QUAD 0x00 "DmaCfgReg,DMA Configuration Register"
            BITFLD.QUAD 0x00 0. "DMA_EN    ,DMA_EN" "0,1"
    GROUP.QUAD 0x3a0++0x08
        LINE.QUAD 0x00 "ChEnReg,DW_ahb_dmac Channel Enable Register"
            BITFLD.QUAD 0x00 8.--15. "CH_EN_WE    ,CH_EN_WE"
            BITFLD.QUAD 0x00 0.--7. "CH_EN    ,CH_EN"
TREE.END
TREE.END

TREE "XIP MODULE"
    BASE ad:0xd00000
    GROUP.LONG 0x0++0x3
        LINE.LONG 0x00 "XCTRLR0,Control Register 0"
            BITFLD.LONG 0x00 24. "SSTE    ,SSTE" "0,1"
            BITFLD.LONG 0x00 23. "RSVD_CTRLR0_23    ,RSVD_CTRLR0_23" "0,1"
            BITFLD.LONG 0x00 21.--22. "SPI_FRF    ,SPI_FRF" "0,1,2,3"
            BITFLD.LONG 0x00 16.--20. "DFS_32    ,DFS_32"
            NEWLINE
            BITFLD.LONG 0x00 12.--15. "CFS    ,CFS"
            BITFLD.LONG 0x00 11. "SRL    ,SRL" "0,1"
            BITFLD.LONG 0x00 10. "RSVD_CTRLR0_10     ,RSVD_CTRLR0_10 " "0,1"
            BITFLD.LONG 0x00 8.--9. "TMOD    ,TMOD" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 7. "SCPOL    ,SCPOL" "0,1"
            BITFLD.LONG 0x00 6. "SCPH    ,SCPH" "0,1"
            BITFLD.LONG 0x00 4.--5. "FRF    ,FRF" "0,1,2,3"
            BITFLD.LONG 0x00 0.--3. "RSVD_CTRLR0_3_0    ,RSVD_CTRLR0_3_0"
            NEWLINE
    GROUP.LONG 0x4++0x3
        LINE.LONG 0x00 "XCTRLR1,Control Register 1"
            BITFLD.LONG 0x00 0.--15. "NDF    ,NDF"
    GROUP.LONG 0x8++0x3
        LINE.LONG 0x00 "XSSIENR,SSI Enable Register"
            BITFLD.LONG 0x00 0. "SSI_EN    ,SSI_EN" "0,1"
    GROUP.LONG 0xC++0x3
        LINE.LONG 0x00 "XMWCR,Microwire Control Register"
            BITFLD.LONG 0x00 2. "MHS    ,MHS" "0,1"
            BITFLD.LONG 0x00 1. "MDD    ,MDD" "0,1"
            BITFLD.LONG 0x00 0. "MWMOD    ,MWMOD" "0,1"
    GROUP.LONG 0x10++0x3
        LINE.LONG 0x00 "XSER,Slave Enable Register"
            BITFLD.LONG 0x00 0. "SER    ,SER" "0,1"
    GROUP.LONG 0x14++0x3
        LINE.LONG 0x00 "XBAUDR,Baud Rate Select"
            BITFLD.LONG 0x00 0.--15. "SCKDV    ,SCKDV"
    GROUP.LONG 0x18++0x3
        LINE.LONG 0x00 "XTXFTLR,Transmit FIFO Threshold Level"
            BITFLD.LONG 0x00 0.--4. "TFT    ,TFT"
    GROUP.LONG 0x1c++0x3
        LINE.LONG 0x00 "XRXFTLR,Receive FIFO Threshold Level"
            BITFLD.LONG 0x00 0.--4. "RFT    ,RFT"
    GROUP.LONG 0x20++0x3
        LINE.LONG 0x00 "XTXFLR,Transmit FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "TXTFL    ,TXTFL"
    GROUP.LONG 0x24++0x3
        LINE.LONG 0x00 "XRXFLR,Receive FIFO Level Register"
            BITFLD.LONG 0x00 0.--5. "RXTFL    ,RXTFL"
    GROUP.LONG 0x28++0x3
        LINE.LONG 0x00 "XSR,Status Register"
            BITFLD.LONG 0x00 6. "DCOL    ,DCOL" "0,1"
            BITFLD.LONG 0x00 5. "RSVD_SR_5     ,RSVD_SR_5 " "0,1"
            BITFLD.LONG 0x00 4. "RFF    ,RFF" "0,1"
            BITFLD.LONG 0x00 3. "RFNE    ,RFNE" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 2. "TFE    ,TFE" "0,1"
            BITFLD.LONG 0x00 1. "TFNF    ,TFNF" "0,1"
            BITFLD.LONG 0x00 0. "BUSY    ,BUSY" "0,1"
    GROUP.LONG 0x2c++0x3
        LINE.LONG 0x00 "XIMR,Interrupt Mask Register"
            BITFLD.LONG 0x00 5. "MSTIM    ,MSTIM" "0,1"
            BITFLD.LONG 0x00 4. "RXFIM    ,RXFIM" "0,1"
            BITFLD.LONG 0x00 3. "RXOIM    ,RXOIM" "0,1"
            BITFLD.LONG 0x00 2. "RXUIM    ,RXUIM" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIM    ,TXOIM" "0,1"
            BITFLD.LONG 0x00 0. "TXEIM    ,TXEIM" "0,1"
    GROUP.LONG 0x30++0x3
        LINE.LONG 0x00 "XISR,Interrupt Status Register"
            BITFLD.LONG 0x00 5. "MSTIS    ,MSTIS" "0,1"
            BITFLD.LONG 0x00 4. "RXFIS    ,RXFIS" "0,1"
            BITFLD.LONG 0x00 3. "RXOIS    ,RXOIS" "0,1"
            BITFLD.LONG 0x00 2. "RXUIS    ,RXUIS" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIS    ,TXOIS" "0,1"
            BITFLD.LONG 0x00 0. "TXEIS    ,TXEIS" "0,1"
    GROUP.LONG 0x34++0x3
        LINE.LONG 0x00 "XRISR,Raw Interrupt Status Register"
            BITFLD.LONG 0x00 5. "MSTIR    ,MSTIR" "0,1"
            BITFLD.LONG 0x00 4. "RXFIR    ,RXFIR" "0,1"
            BITFLD.LONG 0x00 3. "RXOIR    ,RXOIR" "0,1"
            BITFLD.LONG 0x00 2. "RXUIR    ,RXUIR" "0,1"
            NEWLINE
            BITFLD.LONG 0x00 1. "TXOIR    ,TXOIR" "0,1"
            BITFLD.LONG 0x00 0. "TXEIR    ,TXEIR" "0,1"
    GROUP.LONG 0x38++0x3
        LINE.LONG 0x00 "XTXOICR,Transmit FIFO Overflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "TXOICR    ,TXOICR" "0,1"
    GROUP.LONG 0x3c++0x3
        LINE.LONG 0x00 "XRXOICR,Receive FIFO Overflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "RXOICR    ,RXOICR" "0,1"
    GROUP.LONG 0x40++0x3
        LINE.LONG 0x00 "XRXUICR,Receive FIFO Underflow Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "RXUICR    ,RXUICR" "0,1"
    GROUP.LONG 0x44++0x3
        LINE.LONG 0x00 "XMSTICR,Multi-Master Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "MSTICR    ,MSTICR" "0,1"
    GROUP.LONG 0x48++0xf
        LINE.LONG 0x00 "XICR,Interrupt Clear Register"
            BITFLD.LONG 0x00 0. "ICR    ,ICR" "0,1"
    GROUP.LONG 0x58++0x3
        LINE.LONG 0x00 "XIDR,Identification Register"
            HEXMASK.LONG 0x00 0.--31. "IDCODE    ,IDCODE"
    GROUP.LONG 0x5c++0x3
        LINE.LONG 0x00 "XSSI_VERSION_ID,coreKit version ID Register"
            HEXMASK.LONG 0x00 0.--31. "SSI_COMP_VERSION    ,SSI_COMP_VERSION"
    
	GROUP.LONG 0x60++0x3
        LINE.LONG 0x00 "XDR1 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
	GROUP.LONG 0x64++0x3
        LINE.LONG 0x00 "XDR1 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x68++0x3
        LINE.LONG 0x00 "XDR2 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x6C++0x3
        LINE.LONG 0x00 "XDR3 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x70++0x3
        LINE.LONG 0x00 "XDR4 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x74++0x3
        LINE.LONG 0x00 "XDR5 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x78++0x3
        LINE.LONG 0x00 "XDR6 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x7C++0x3
        LINE.LONG 0x00 "XDR7 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x80++0x3
        LINE.LONG 0x00 "XDR8 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x84++0x3
        LINE.LONG 0x00 "XDR9 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x88++0x3
        LINE.LONG 0x00 "XDR10 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x8C++0x3
        LINE.LONG 0x00 "XDR12 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x90++0x3
        LINE.LONG 0x00 "XDR12 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x94++0x3
        LINE.LONG 0x00 "XDR13 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x98++0x3
        LINE.LONG 0x00 "XDR14 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"
    GROUP.LONG 0x9C++0x3
        LINE.LONG 0x00 "XDR15 (for x = 0; x <= 15),Data Register x"
            HEXMASK.LONG 0x00 0.--31. "DR    ,DR"			
			
    GROUP.LONG 0xf0++0x3
        LINE.LONG 0x00 "XRX_SAMPLE_DLY,RX Sample Delay Register"
            BITFLD.LONG 0x00 0.--4. "RSD    ,RSD"
    GROUP.LONG 0xf4++0x7
        LINE.LONG 0x00 "XSPI_CTRLR0,SPI Control Register"
            BITFLD.LONG 0x00 11.--15. "WAIT_CYCLES    ,WAIT_CYCLES"
            BITFLD.LONG 0x00 10. "RSVD_SPI_CTRLR0_10    ,RSVD_SPI_CTRLR0_10" "0,1"
            BITFLD.LONG 0x00 8.--9. "INST_L    ,INST_L" "0,1,2,3"
            BITFLD.LONG 0x00 6.--7. "RSVD_SPI_CTRLR0_6_7    ,RSVD_SPI_CTRLR0_6_7" "0,1,2,3"
            NEWLINE
            BITFLD.LONG 0x00 2.--5. "ADDR_L    ,ADDR_L"
            BITFLD.LONG 0x00 0.--1. "TRANS_TYPE    ,TRANS_TYPE" "0,1,2,3"
    GROUP.LONG 0xFC++0x3
        LINE.LONG 0x00 "XRSVD,RSVD - Reserved address location"
            BITFLD.LONG 0x00 0.--31. "RSVD    ,RSVD"
    GROUP.LONG 0x100++0x3
        LINE.LONG 0x00 "XIP_ENAB,XIP Enable Register"
            BITFLD.LONG 0x00 0. "XIP_ENAB    ,XIP_ENAB" "0,1"
    GROUP.LONG 0x104++0x3
        LINE.LONG 0x00 "XRDSRCR,XIP RDSR Command Register"
            BITFLD.LONG 0x00 25.--26. "XIP_RDSR_INST_LEN    ,XIP_RDSR_INST_LEN" "0,1,2,3"
            BITFLD.LONG 0x00 21.--24. "XIP_RDSR_ADDR_LEN    ,XIP_RDSR_ADDR_LEN"
            BITFLD.LONG 0x00 16.--20. "XIP_RDSR_DFS    ,XIP_RDSR_DFS"
            BITFLD.LONG 0x00 0.--15. "XIP_RDSR_CMD    ,XIP_RDSR_CMD"
            NEWLINE
    GROUP.LONG 0x108++0x3
        LINE.LONG 0x00 "XRDCR, XIP Read Command Register"
            BITFLD.LONG 0x00 25.--26. "XIP_READ_INST_LEN    ,XIP_READ_INST_LEN" "0,1,2,3"
            BITFLD.LONG 0x00 21.--24. "XIP_READ_ADDR_LEN    ,XIP_READ_ADDR_LEN"
            BITFLD.LONG 0x00 16.--20. "XIP_READ_DFS    ,XIP_READ_DFS"
            BITFLD.LONG 0x00 0.--15. "XIP_READ_CMD    ,XIP_READ_CMD"
            NEWLINE
    GROUP.LONG 0x10C++0x3
        LINE.LONG 0x00 "XWENACR, XIP WENA Command Register"
            BITFLD.LONG 0x00 25.--26. "XIP_WENA_INST_LEN    ,XIP_WENA_INST_LEN" "0,1,2,3"
            BITFLD.LONG 0x00 21.--24. "XIP_WENA_ADDR_LEN    ,XIP_WENA_ADDR_LEN"
            BITFLD.LONG 0x00 16.--20. "XIP_WENA_DFS    ,XIP_WENA_DFS"
            BITFLD.LONG 0x00 0.--15. "XIP_WENA_CMD    ,XIP_WENA_CMD"
            NEWLINE
    GROUP.LONG 0x110++0x3
        LINE.LONG 0x00 "XWECR,XIP Write Command Register"
            BITFLD.LONG 0x00 25.--26. "XIP_WRITE_INST_LEN    ,XIP_WRITE_INST_LEN" "0,1,2,3"
            BITFLD.LONG 0x00 21.--24. "XIP_WRITE_ADDR_LEN    ,XIP_WRITE_ADDR_LEN"
            BITFLD.LONG 0x00 16.--20. "XIP_WRITE_DFS    ,XIP_WRITE_DFS"
            BITFLD.LONG 0x00 0.--15. "XIP_WRITE_CMD    ,XIP_WRITE_CMD"
            NEWLINE
    GROUP.LONG 0x114++0x3
        LINE.LONG 0x00 "XSSCR,XIP Suspend Command Register"
            BITFLD.LONG 0x00 25.--26. "XIP_SUSPEND_INST_LEN    ,XIP_SUSPEND_INST_LEN" "0,1,2,3"
            BITFLD.LONG 0x00 21.--24. "XIP_SUSPEND_ADDR_LEN    ,XIP_SUSPEND_ADDR_LEN"
            BITFLD.LONG 0x00 16.--20. "XIP_SUSPEND_DFS    ,XIP_SUSPEND_DFS"
            BITFLD.LONG 0x00 0.--15. "XIP_SUSPEND_CMD    ,XIP_SUSPEND_CMD"
            NEWLINE
    GROUP.LONG 0x118++0x3
        LINE.LONG 0x00 "XRDFSRCR,XIP RDFSR Command Register"
            BITFLD.LONG 0x00 25.--26. "XIP_RDFSR_INST_LEN    ,XIP_RDFSR_INST_LEN" "0,1,2,3"
            BITFLD.LONG 0x00 21.--24. "XIP_RDFSR_ADDR_LEN    ,XIP_RDFSR_ADDR_LEN"
            BITFLD.LONG 0x00 16.--20. "XIP_RDFSR_DFS    ,XIP_RDFSR_DFS"
            BITFLD.LONG 0x00 0.--15. "XIP_RDFSR_CMD    ,XIP_RDFSR_CMD"
            NEWLINE
    GROUP.LONG 0x11C++0x3
        LINE.LONG 0x00 "XISOR,XIP Instruction Section Offset Register"
            BITFLD.LONG 0x00 0.--31. "XIP_INSOFT    ,XIP_INSOFT"
    GROUP.LONG 0x120++0x3
        LINE.LONG 0x00 "XDSOR,XIP Data Section Offset Register"
            BITFLD.LONG 0x00 0.--31. "XIP_DATOFT    ,XIP_DATOFT"
    GROUP.LONG 0x124++0x3
        LINE.LONG 0x00 "AMR,AES Mode Register"
            BITFLD.LONG 0x00 8.--31. "XIP_TMF_MASK    ,XIP_TMF_MASK"
            BITFLD.LONG 0x00 3.--7. "AMR_RSV_7_3    ,AMR_RSV_7_3"
            BITFLD.LONG 0x00 2. "XIP_TMF    ,XIP_TMF" "0,1"
            BITFLD.LONG 0x00 0.--1. "AES_MODE    ,AES_MODE" "0,1,2,3"
            NEWLINE
    GROUP.LONG 0x128++0x3
        LINE.LONG 0x00 "ACDMR,AES Cipher/Decipher Mode Register"
            BITFLD.LONG 0x00 0. "AES_CD    ,AES_CD" "0,1"
    GROUP.LONG 0x12C++0x3
        LINE.LONG 0x00 "ARSR,AES Radom Seed Register"
            BITFLD.LONG 0x00 0.--19. "AES_SEED    ,AES_SEED"
    GROUP.LONG 0x130++0x3
        LINE.LONG 0x00 "ATVR0,AES Tweak Value Register 0"
            BITFLD.LONG 0x00 0.--31. "AES_TWEAK_0    ,AES_TWEAK_0"
    GROUP.LONG 0x134++0x3
        LINE.LONG 0x00 "ATVR1,AES Tweak Value Register 1"
            BITFLD.LONG 0x00 0.--31. "AES_TWEAK_1    ,AES_TWEAK_1"
    GROUP.LONG 0x138++0x3
        LINE.LONG 0x00 "ATVR2,AES Tweak Value Register 2"
            BITFLD.LONG 0x00 0.--31. "AES_TWEAK_2    ,AES_TWEAK_2"
    GROUP.LONG 0x13C++0x3
        LINE.LONG 0x00 "ATVR3,AES Tweak Value Register 3"
            BITFLD.LONG 0x00 0.--31. "AES_TWEAK_3    ,AES_TWEAK_3"
    GROUP.LONG 0x140++0x3
        LINE.LONG 0x00 "AVBR,AES Valid Block Register"
            BITFLD.LONG 0x00 0.--2. "AES_VLD_BLK    ,AES_VLD_BLK"
    GROUP.LONG 0x144++0x3
        LINE.LONG 0x00 "ALBSR,AES Last Block Size Register"
            BITFLD.LONG 0x00 0.--7. "AES_LAST_BLK_SZ    ,AES_LAST_BLK_SZ"
    GROUP.LONG 0x148++0x3
        LINE.LONG 0x00 "AIDR0,AES Input Data Register 0"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_0    ,AES_DIN_0"
    GROUP.LONG 0x14C++0x3
        LINE.LONG 0x00 "AIDR1,AES Input Data Register 1"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_1    ,AES_DIN_1"
    GROUP.LONG 0x150++0x3
        LINE.LONG 0x00 "AIDR2,AES Input Data Register 2"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_2    ,AES_DIN_2"
    GROUP.LONG 0x154++0x3
        LINE.LONG 0x00 "AIDR3,AES Input Data Register 3"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_3    ,AES_DIN_3"
    GROUP.LONG 0x158++0x3
        LINE.LONG 0x00 "AIDR4,AES Input Data Register 4"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_4    ,AES_DIN_4"
    GROUP.LONG 0x15C++0x3
        LINE.LONG 0x00 "AIDR5,AES Input Data Register 5"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_5    ,AES_DIN_5"
    GROUP.LONG 0x160++0x3
        LINE.LONG 0x00 "AIDR6,AES Input Data Register 6"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_6    ,AES_DIN_6"
    GROUP.LONG 0x164++0x3
        LINE.LONG 0x00 "AIDR7,AES Input Data Register 7"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_7    ,AES_DIN_7"
    GROUP.LONG 0x168++0x3
        LINE.LONG 0x00 "AIDR8,AES Input Data Register 8"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_8    ,AES_DIN_8"
    GROUP.LONG 0x16C++0x3
        LINE.LONG 0x00 "AIDR9,AES Input Data Register 9"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_9    ,AES_DIN_9"
    GROUP.LONG 0x170++0x3
        LINE.LONG 0x00 "AIDR10,AES Input Data Register 10"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_10    ,AES_DIN_10"
    GROUP.LONG 0x174++0x3
        LINE.LONG 0x00 "AIDR11,AES Input Data Register 11"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_11    ,AES_DIN_11"
    GROUP.LONG 0x178++0x3
        LINE.LONG 0x00 "AIDR12,AES Input Data Register 12"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_12    ,AES_DIN_12"
    GROUP.LONG 0x17C++0x3
        LINE.LONG 0x00 "AIDR13,AES Input Data Register 13"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_13    ,AES_DIN_13"
    GROUP.LONG 0x180++0x3
        LINE.LONG 0x00 "AIDR14,AES Input Data Register 14"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_14    ,AES_DIN_14"
    GROUP.LONG 0x184++0x3
        LINE.LONG 0x00 "AIDR15,AES Input Data Register 15"
            BITFLD.LONG 0x00 0.--31. "AES_DIN_15    ,AES_DIN_15"
    GROUP.LONG 0x188++0x3
        LINE.LONG 0x00 "AWER,AES Write Enable Register"
            BITFLD.LONG 0x00 0. "AES_UPDATE    ,AES_UPDATE" "0,1"
    GROUP.LONG 0x18C++0x3
        LINE.LONG 0x00 "ANSR,AES New Stream Register"
            BITFLD.LONG 0x00 0. "AES_NEW_STREAM    ,AES_NEW_STREAM" "0,1"
    GROUP.LONG 0x190++0x3
        LINE.LONG 0x00 "AIDVR,AES Input Data Validation Register"
            BITFLD.LONG 0x00 0. "AES_DIN_VAL    ,AES_DIN_VAL" "0,1"
    GROUP.LONG 0x194++0x3
        LINE.LONG 0x00 "ADSR,AES Done Signal Register"
            BITFLD.LONG 0x00 0. "AES_DONE    ,AES_DONE" "0,1"
    GROUP.LONG 0x198++0x3
        LINE.LONG 0x00 "AODR0,AES Output Data Register 0"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_0    ,AES_DOUT_0"
    GROUP.LONG 0x19C++0x3
        LINE.LONG 0x00 "AODR1,AES Output Data Register 1"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_1    ,AES_DOUT_1"
    GROUP.LONG 0x1A0++0x3
        LINE.LONG 0x00 "AODR2,AES Output Data Register 2"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_2    ,AES_DOUT_2"
    GROUP.LONG 0x1A4++0x3
        LINE.LONG 0x00 "AODR3,AES Output Data Register 3"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_3    ,AES_DOUT_3"
    GROUP.LONG 0x1A8++0x3
        LINE.LONG 0x00 "AODR4,AES Output Data Register 4"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_4    ,AES_DOUT_4"
    GROUP.LONG 0x1AC++0x3
        LINE.LONG 0x00 "AODR5,AES Output Data Register 5"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_5    ,AES_DOUT_5"
    GROUP.LONG 0x1B0++0x3
        LINE.LONG 0x00 "AODR6,AES Output Data Register 6"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_6    ,AES_DOUT_6"
    GROUP.LONG 0x1B4++0x3
        LINE.LONG 0x00 "AODR7,AES Output Data Register 7"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_7    ,AES_DOUT_7"
    GROUP.LONG 0x1B8++0x3
        LINE.LONG 0x00 "AODR8,AES Output Data Register 8"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_8    ,AES_DOUT_8"
    GROUP.LONG 0x1BC++0x3
        LINE.LONG 0x00 "AODR9,AES Output Data Register 9"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_9    ,AES_DOUT_9"
    GROUP.LONG 0x1C0++0x3
        LINE.LONG 0x00 "AODR10,AES Output Data Register 10"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_10    ,AES_DOUT_10"
    GROUP.LONG 0x1C4++0x3
        LINE.LONG 0x00 "AODR11,AES Output Data Register 11"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_11    ,AES_DOUT_11"
    GROUP.LONG 0x1C8++0x3
        LINE.LONG 0x00 "AODR12,AES Output Data Register 12"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_12    ,AES_DOUT_12"
    GROUP.LONG 0x1CC++0x3
        LINE.LONG 0x00 "AODR13,AES Output Data Register 13"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_13    ,AES_DOUT_13"
    GROUP.LONG 0x1D0++0x3
        LINE.LONG 0x00 "AODR14,AES Output Data Register 14"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_14    ,AES_DOUT_14"
    GROUP.LONG 0x1D4++0x3
        LINE.LONG 0x00 "AODR15,AES Output Data Register 15"
            BITFLD.LONG 0x00 0.--31. "AES_DOUT_15    ,AES_DOUT_15"
    GROUP.LONG 0x1D8++0x3
        LINE.LONG 0x00 "XABECR, XIP AHB Bus Endian Control Register"
            BITFLD.LONG 0x00 8.--9. "AES_DOUT_15    ,AES_DOUT_15" "0,1,2,3"
            BITFLD.LONG 0x00 2.--7. "XABECR_RSV_7_2    ,XABECR_RSV_7_2"
            BITFLD.LONG 0x00 0.--1. "AES_DOUT_16    ,AES_DOUT_16" "0,1,2,3"
    GROUP.LONG 0x1DC++0x3
        LINE.LONG 0x00 "XADBECR, XIP AES Data Bus Endian Control Register"
            BITFLD.LONG 0x00 2. "XIP_WORD_SWAP    ,XIP_WORD_SWAP" "0,1"
            BITFLD.LONG 0x00 1. "XIP_BYTE_SWAP    ,XIP_BYTE_SWAP" "0,1"
            BITFLD.LONG 0x00 0. "XIP_BIT_SWAP    ,XIP_BIT_SWAP" "0,1"
    GROUP.LONG 0x1E0++0x3
        LINE.LONG 0x00 "XIBCR,XIP Instruction Buffer Control Register"
            BITFLD.LONG 0x00 0.--3. "XIP_INSBUF_LEN    ,XIP_INSBUF_LEN"
    GROUP.LONG 0x1E4++0x3
        LINE.LONG 0x00 "XRBCR,XIP Read Buffer Control Register"
            BITFLD.LONG 0x00 0.--3. "XIP_RDBUF_LEN    ,XIP_RDBUF_LEN"
    GROUP.LONG 0x1E8++0x3
        LINE.LONG 0x00 "XWRBCR, XIP Write Buffer Control Register"
            BITFLD.LONG 0x00 0.--3. "XIP_WRBUF_LEN    ,XIP_WRBUF_LEN"
    GROUP.LONG 0x1EC++0x3
        LINE.LONG 0x00 "XWPBCR,XIP WIP Bit Control Register"
            BITFLD.LONG 0x00 16.--17. "XIP_WIP_CNT    ,XIP_WIP_CNT" "0,1,2,3"
            BITFLD.LONG 0x00 0.--15. "XIP_WIP_BIT    ,XIP_WIP_BIT"
    GROUP.LONG 0x1F0++0x3
        LINE.LONG 0x00 "XXBCR,XIP XSB Bit Control Register"
            BITFLD.LONG 0x00 16.--17. "XIP_XSB_CNT    ,XIP_XSB_CNT" "0,1,2,3"
            BITFLD.LONG 0x00 0.--15. "XIP_XSB_BIT    ,XIP_XSB_BIT"
    GROUP.LONG 0x1F4++0x3
        LINE.LONG 0x00 "XXLCR,XIP XSB Latency Counter Register"
            BITFLD.LONG 0x00 0.--31. "XIP_XSB_LAT    ,XIP_XSB_LAT"
    GROUP.LONG 0x1F8++0x3
        LINE.LONG 0x00 "XEFBR,XIP Erase Flag Bit Register"
            BITFLD.LONG 0x00 0. "XIP_ERASE_FLAG    ,XIP_ERASE_FLAG" "0,1"
    GROUP.LONG 0x1FC++0x03
        LINE.LONG 0x00 "XPFBR,XIP Program Flag Bit Register"
            BITFLD.LONG 0x00 0. "XIP_PRGM_FLAG    ,XIP_PRGM_FLAG" "0,1"
TREE.END

TREE "OTP MODULE"
    BASE ad:0xbf0000
    GROUP.LONG 0x0000++0x3
        LINE.LONG 0x00 "MEM_BIST_1,MEM BIST 1"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0004++0x3
        LINE.LONG 0x00 "MEM_BIST_2,MEM BIST 2"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0008++0x3
        LINE.LONG 0x00 "MEM_BIST_3,MEM BIST 3"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x000C++0x3
        LINE.LONG 0x00 "MEM_BIST_4,MEM BIST 4"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0010++0x3
        LINE.LONG 0x00 "MEM_BIST_5,MEM BIST 5"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0014++0x3
        LINE.LONG 0x00 "MEM_BIST_6,MEM BIST 6"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0018++0x3
        LINE.LONG 0x00 "MEM_BIST_7,MEM BIST 7"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x001C++0x3
        LINE.LONG 0x00 "MEM_BIST_8,MEM BIST 8"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0020++0x3
        LINE.LONG 0x00 "MEM_BIST_9,MEM BIST 9"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0024++0x3
        LINE.LONG 0x00 "MEM_BIST_10,MEM BIST 10"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0028++0x3
        LINE.LONG 0x00 "MEM_BIST_11,MEM BIST 11"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x002C++0x3
        LINE.LONG 0x00 "MEM_BIST_12,MEM BIST 12"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0030++0x3
        LINE.LONG 0x00 "MEM_BIST_13,MEM BIST 13"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0034++0x3
        LINE.LONG 0x00 "MEM_BIST_14,MEM BIST 14"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0038++0x3
        LINE.LONG 0x00 "MEM_BIST_15,MEM BIST 15"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x003C++0x3
        LINE.LONG 0x00 "MEM_BIST_16,MEM BIST 16"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0040++0x3
        LINE.LONG 0x00 "MEM_BIST_17,MEM BIST 17"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0044++0x3
        LINE.LONG 0x00 "MEM_BIST_18,MEM BIST 18"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0048++0x3
        LINE.LONG 0x00 "MEM_BIST_19,MEM BIST 19"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x004C++0x3
        LINE.LONG 0x00 "MEM_BIST_20,MEM BIST 20"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0050++0x3
        LINE.LONG 0x00 "MEM_BIST_21,MEM BIST 21"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0054++0x3
        LINE.LONG 0x00 "MEM_BIST_22,MEM BIST 22"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0058++0x3
        LINE.LONG 0x00 "MEM_BIST_23,MEM BIST 23"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x005C++0x3
        LINE.LONG 0x00 "MEM_BIST_24,MEM BIST 24"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0060++0x3
        LINE.LONG 0x00 "MEM_BIST_25,MEM BIST 25"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0064++0x3
        LINE.LONG 0x00 "MEM_BIST_26,MEM BIST 26"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0068++0x3
        LINE.LONG 0x00 "MEM_BIST_27,MEM BIST 27"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x006C++0x3
        LINE.LONG 0x00 "MEM_BIST_28,MEM BIST 28"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0070++0x3
        LINE.LONG 0x00 "MEM_BIST_29,MEM BIST 29"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0074++0x3
        LINE.LONG 0x00 "MEM_BIST_30,MEM BIST 30"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0078++0x3
        LINE.LONG 0x00 "MEM_BIST_31,MEM BIST 31"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x007C++0x3
        LINE.LONG 0x00 "MEM_BIST_32,MEM BIST 32"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0080++0x3
        LINE.LONG 0x00 "MEM_BIST_33,MEM BIST 33"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0084++0x3
        LINE.LONG 0x00 "MEM_BIST_34,MEM BIST 34"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0088++0x3
        LINE.LONG 0x00 "MEM_BIST_35,MEM BIST 35"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x008C++0x3
        LINE.LONG 0x00 "MEM_BIST_36,MEM BIST 36"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0090++0x3
        LINE.LONG 0x00 "MEM_BIST_37,MEM BIST 37"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0094++0x3
        LINE.LONG 0x00 "MEM_BIST_38,MEM BIST 38"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0098++0x3
        LINE.LONG 0x00 "MEM_BIST_39,MEM BIST 39"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x009C++0x3
        LINE.LONG 0x00 "MEM_BIST_40,MEM BIST 40"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00A0++0x3
        LINE.LONG 0x00 "MEM_BIST_41,MEM BIST 41"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00A4++0x3
        LINE.LONG 0x00 "MEM_BIST_42,MEM BIST 42"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00A8++0x3
        LINE.LONG 0x00 "MEM_BIST_43,MEM BIST 43"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00AC++0x3
        LINE.LONG 0x00 "MEM_BIST_44,MEM BIST 44"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00B0++0x3
        LINE.LONG 0x00 "MEM_BIST_45,MEM BIST 45"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00B4++0x3
        LINE.LONG 0x00 "MEM_BIST_46,MEM BIST 46"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00B8++0x3
        LINE.LONG 0x00 "MEM_BIST_47,MEM BIST 47"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00BC++0x3
        LINE.LONG 0x00 "CHIP_INFO_1,JEDEC Information"
            BITFLD.LONG 0x00 0.--31. "JEDEC    ,JEDEC"
    GROUP.LONG 0x00C0++0x3
        LINE.LONG 0x00 "CHIP_INFO_2,JEDEC Information"
            BITFLD.LONG 0x00 0.--31. "JEDEC    ,JEDEC"
    GROUP.LONG 0x00C4++0x3
        LINE.LONG 0x00 "CHIP_INFO_3,JEDEC Information"
            BITFLD.LONG 0x00 0.--31. "JEDEC    ,JEDEC"
    GROUP.LONG 0x00C8++0x3
        LINE.LONG 0x00 "CHIP_INFO_4,JEDEC Information"
            BITFLD.LONG 0x00 0.--31. "JEDEC    ,JEDEC"
    GROUP.LONG 0x00CC++0x3
        LINE.LONG 0x00 "CHIP_INFO_5,CHIP_INFO_5"
            BITFLD.LONG 0x00 28.--31. "PID    ,PID"
            BITFLD.LONG 0x00 24.--27. "FID    ,FID"
            BITFLD.LONG 0x00 16.--23. "WNO    ,WNO"
            BITFLD.LONG 0x00 8.--15. "XLOC    ,XLOC"
            NEWLINE
            BITFLD.LONG 0x00 0.--7. "YLOC    ,YLOC"
    GROUP.LONG 0x00D0++0x3
        LINE.LONG 0x00 "CHIP_INFO_6,CHIP_INFO_6"
            BITFLD.LONG 0x00 16.--31. "SID    ,SID"
            BITFLD.LONG 0x00 0.--15. "LID_L    ,LID_L"
    GROUP.LONG 0x00D4++0x3
        LINE.LONG 0x00 "CHIP_INFO_7,CHIP_INFO_7"
            BITFLD.LONG 0x00 0.--31. "LID_H    ,LID_H"
    GROUP.LONG 0x00D8++0x3
        LINE.LONG 0x00 "CHIP_INFO_8,CHIP_INFO_8"
            BITFLD.LONG 0x00 24.--31. "CRC    ,CRC"
            BITFLD.LONG 0x00 20.--23. "CPHID    ,CPHID"
            BITFLD.LONG 0x00 0.--19. "RSV    ,RSV"
    GROUP.LONG 0x00DC++0x3
        LINE.LONG 0x00 "CHIP_INFO_9,CHIP_INFO_9"
            HEXMASK.LONG 0x00 0.--31. "PNO_L    ,PNO_L"
    GROUP.LONG 0x00E0++0x3
        LINE.LONG 0x00 "CHIP_INFO_10,CHIP_INFO_10"
            HEXMASK.LONG 0x00 0.--31. "PNO_H    ,PNO_H"
    GROUP.LONG 0x00E4++0x3
        LINE.LONG 0x00 "CHIP_INFO_11,CHIP_INFO_11"
            BITFLD.LONG 0x00 28.--31. "FTHID    ,FTHID"
            BITFLD.LONG 0x00 24.--27. "RSV0    ,RSV0"
            BITFLD.LONG 0x00 16.--23. "PRNO    ,PRNO"
            BITFLD.LONG 0x00 8.--15. "FTCRC    ,FTCRC"
            NEWLINE
            BITFLD.LONG 0x00 1.--7. "RSV1    ,RSV1"
            BITFLD.LONG 0x00 0. "CPD    ,CPD" "0,1"
    GROUP.LONG 0x00E8++0x3
        LINE.LONG 0x00 "AES_PRTC,AES Protection"
            BITFLD.LONG 0x00 2.--31. "RSV    ,RSV"
            BITFLD.LONG 0x00 1. "KRD    ,KRD" "0,1"
            BITFLD.LONG 0x00 0. "KPD    ,KPD" "0,1"
    GROUP.LONG 0x00EC++0x3
        LINE.LONG 0x00 "AES_KEY1_31_0,AES_KEY1_31_0"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00F0++0x3
        LINE.LONG 0x00 "AES_KEY1_63_32,AES_KEY1_63_32"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00F4++0x3
        LINE.LONG 0x00 "AES_KEY1_95_64,AES_KEY1_95_64"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00F8++0x3
        LINE.LONG 0x00 "AES_KEY1_127_96,AES_KEY1_127_96"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x00FC++0x3
        LINE.LONG 0x00 "AES_KEY1_159_128,AES_KEY1_159_128"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0100++0x3
        LINE.LONG 0x00 "AES_KEY1_191_160,AES_KEY1_191_160"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0104++0x3
        LINE.LONG 0x00 "AES_KEY1_223_192,AES_KEY1_223_192"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0108++0x3
        LINE.LONG 0x00 "AES_KEY1_255_224,AES_KEY1_255_224"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x010C++0x3
        LINE.LONG 0x00 "AES_KEY2_31_0,AES_KEY2_31_0"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0110++0x3
        LINE.LONG 0x00 "AES_KEY2_63_32,AES_KEY2_63_32"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0114++0x3
        LINE.LONG 0x00 "AES_KEY2_95_64,AES_KEY2_95_64"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0118++0x3
        LINE.LONG 0x00 "AES_KEY2_127_96,AES_KEY2_127_96"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x011C++0x3
        LINE.LONG 0x00 "AES_KEY2_159_128,AES_KEY2_159_128"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0120++0x3
        LINE.LONG 0x00 "AES_KEY2_191_160,AES_KEY2_191_160"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0124++0x3
        LINE.LONG 0x00 "AES_KEY2_223_192,AES_KEY2_223_192"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0128++0x3
        LINE.LONG 0x00 "AES_KEY2_255_224,AES_KEY2_255_224"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x012C++0x3
        LINE.LONG 0x00 "AES_TWK_31_0,AES_TWK_31_0"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0130++0x3
        LINE.LONG 0x00 "AES_TWK_63_32,AES_TWK_63_32"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0134++0x3
        LINE.LONG 0x00 "AES_TWK_95_64,AES_TWK_95_64"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0138++0x3
        LINE.LONG 0x00 "AES_TWK_127_96,AES_TWK_127_96"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x013C++0x3
        LINE.LONG 0x00 "AES_CNTRL,AES_CNTRL"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0140++0x3
        LINE.LONG 0x00 "SCRTY_1,Security 1"
            BITFLD.LONG 0x00 3.--31. "RSV    ,RSV"
            BITFLD.LONG 0x00 2. "HD    ,HD" "0,1"
            BITFLD.LONG 0x00 1. "JD    ,JD" "0,1"
            BITFLD.LONG 0x00 0. "SE    ,SE" "0,1"
            NEWLINE
    GROUP.LONG 0x0144++0x3
        LINE.LONG 0x00 "SCRTY_2,Security 2"
            BITFLD.LONG 0x00 30.--31. "RSV    ,RSV" "0,1,2,3"
            BITFLD.LONG 0x00 1.--29. "CAN0_ID    ,CAN0_ID"
            BITFLD.LONG 0x00 0. "XTD    ,XTD" "0,1"
    GROUP.LONG 0x0148++0x3
        LINE.LONG 0x00 "SCRTY_3,Security 3"
            BITFLD.LONG 0x00 2.--31. "RSV    ,RSV"
            BITFLD.LONG 0x00 1. "FDD1    ,FDD1" "0,1"
            BITFLD.LONG 0x00 0. "FDD0    ,FDD0" "0,1"
    GROUP.LONG 0x014C++0x3
        LINE.LONG 0x00 "SCRTY_4,Security 4"
            BITFLD.LONG 0x00 0.--31. "CANBD    ,CANBD"
    GROUP.LONG 0x0150++0x3
        LINE.LONG 0x00 "SCRTY_5,Security 5"
            BITFLD.LONG 0x00 0.--31. "SDF0    ,SDF0"
    GROUP.LONG 0x0154++0x3
        LINE.LONG 0x00 "SCRTY_6,Security 6"
            BITFLD.LONG 0x00 0.--31. "SDF1    ,SDF1"
    GROUP.LONG 0x0158++0x3
        LINE.LONG 0x00 "ANA_1,Reserved for analog and client 1"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x015C++0x3
        LINE.LONG 0x00 "ANA_2,Reserved for analog and client 2"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0160++0x3
        LINE.LONG 0x00 "ANA_3,Reserved for analog and client 3"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0164++0x3
        LINE.LONG 0x00 "ANA_4,Reserved for analog and client 4"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0168++0x3
        LINE.LONG 0x00 "ANA_5,Reserved for analog and client 5"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x016C++0x3
        LINE.LONG 0x00 "ANA_6,Reserved for analog and client 6"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0170++0x3
        LINE.LONG 0x00 "ANA_7,Reserved for analog and client 7"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0174++0x3
        LINE.LONG 0x00 "ANA_8,Reserved for analog and client 8"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0178++0x3
        LINE.LONG 0x00 "ANA_9,Reserved for analog and client 9"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x017C++0x3
        LINE.LONG 0x00 "ANA_10,Reserved for analog and client 10"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0180++0x3
        LINE.LONG 0x00 "ANA_11,Reserved for analog and client 11"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0184++0x3
        LINE.LONG 0x00 "ANA_12,Reserved for analog and client 12"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0188++0x3
        LINE.LONG 0x00 "ANA_13,Reserved for analog and client 13"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x018C++0x3
        LINE.LONG 0x00 "ANA_14,Reserved for analog and client 14"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0190++0x3
        LINE.LONG 0x00 "ANA_15,Reserved for analog and client 15"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0194++0x3
        LINE.LONG 0x00 "ANA_16,Reserved for analog and client 16"
            BITFLD.LONG 0x00 0.--31. "DAT    ,DAT"
    GROUP.LONG 0x0198++0x7
        LINE.LONG 0x00 "RO_ECC_ERR,Read only for ECC error"
            BITFLD.LONG 0x00 2.--31. "RSV    ,RSV"
            BITFLD.LONG 0x00 1. "DBL    ,DBL" "0,1"
            BITFLD.LONG 0x00 0. "SIG    ,SIG" "0,1"
    GROUP.LONG 0x01A0++0x3
        LINE.LONG 0x00 "RO_1,Read only register for debug"
            BITFLD.LONG 0x00 1.--31. "RSV    ,RSV"
            BITFLD.LONG 0x00 0. "CPD    ,CPD" "0,1"
    GROUP.LONG 0x01A4++0x3
        LINE.LONG 0x00 "RO_2,Read only register for debug"
            BITFLD.LONG 0x00 2.--31. "RSV    ,RSV"
            BITFLD.LONG 0x00 1. "KRD    ,KRD" "0,1"
            BITFLD.LONG 0x00 0. "KPD    ,KPD" "0,1"
    GROUP.LONG 0x01A8++0x3
        LINE.LONG 0x00 "RO_3,Read only register for debug"
            BITFLD.LONG 0x00 3.--31. "RSV    ,RSV"
            BITFLD.LONG 0x00 2. "HD    ,HD" "0,1"
            BITFLD.LONG 0x00 1. "JD    ,JD" "0,1"
            BITFLD.LONG 0x00 0. "SE    ,SE" "0,1"
            NEWLINE
    GROUP.LONG 0x01AC++0x3
        LINE.LONG 0x00 "RO_4,Read only register for debug"
            BITFLD.LONG 0x00 30.--31. "RSV    ,RSV" "0,1,2,3"
            BITFLD.LONG 0x00 1.--29. "CAN0_ID    ,CAN0_ID"
            BITFLD.LONG 0x00 0. "XTD    ,XTD" "0,1"
    GROUP.LONG 0x01B0++0x3
        LINE.LONG 0x00 "RO_5,Read only register for debug"
            BITFLD.LONG 0x00 2.--31. "RSV    ,RSV"
            BITFLD.LONG 0x00 1. "FDD1    ,FDD1" "0,1"
            BITFLD.LONG 0x00 0. "FDD0    ,FDD0" "0,1"
    GROUP.LONG 0x01B4++0x3
        LINE.LONG 0x00 "RO_6,Read only register for debug"
            BITFLD.LONG 0x00 0.--31. "CANBD    ,CANBD"
    GROUP.LONG 0x01B8++0x3
        LINE.LONG 0x00 "RO_7,Read only register for debug"
            BITFLD.LONG 0x00 0.--31. "SDF0    ,SDF0"
    GROUP.LONG 0x01BC++0x03
        LINE.LONG 0x00 "RO_8,Read only register for debug"
            BITFLD.LONG 0x00 0.--31. "SDF1    ,SDF1"
TREE.END

;=====END===========